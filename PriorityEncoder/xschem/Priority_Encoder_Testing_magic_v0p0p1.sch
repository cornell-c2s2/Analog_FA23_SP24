v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/Analog_FA23_SP24/PriorityEncoder/Priority_Encoder_v0p0p1.sym} -130 120 0 0 {name=x1}
C {devices/iopin.sym} -280 50 2 0 {name=p2 lab=D0}
C {devices/iopin.sym} -280 70 2 0 {name=p3 lab=D1}
C {devices/iopin.sym} -280 90 2 0 {name=p1 lab=D2}
C {devices/iopin.sym} -280 110 2 0 {name=p4 lab=D3}
C {devices/iopin.sym} -280 130 2 0 {name=p5 lab=D4}
C {devices/iopin.sym} -280 150 2 0 {name=p6 lab=D5}
C {devices/iopin.sym} -280 170 2 0 {name=p7 lab=D6}
C {devices/iopin.sym} -280 190 2 0 {name=p8 lab=D7}
C {devices/iopin.sym} 20 50 0 0 {name=p9 lab=Q0}
C {devices/iopin.sym} 20 70 0 0 {name=p10 lab=Q1}
C {devices/iopin.sym} 20 90 0 0 {name=p11 lab=Q2}
