** sch_path: PTAT/xschem/untitled.sch
**.subckt untitled
XR1 GND net1 GND sky130_fd_pr__res_xhigh_po_5p73 L=42.98 mult=1 m=1
I0 GND net1 1m
**.ends
.GLOBAL GND
.end
