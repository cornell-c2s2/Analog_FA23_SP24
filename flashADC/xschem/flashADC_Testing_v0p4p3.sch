v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 3025 -2178.75 3825 -1778.75 {flags=graph
y1=-0.36
y2=1.44
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 3025 -2578.75 3825 -2178.75 {flags=graph
y1=-0.06
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y1
v1
vin
a1
q1"}
B 2 3025 -2978.75 3825 -2578.75 {flags=graph
y1=-0.058
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 5 6 8 21"
node="y2
v2
vin
a2
q2"}
B 2 3025 -3378.75 3825 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y3
v3
vin
a3
q3"}
B 2 3025 -3778.75 3825 -3378.75 {flags=graph
y1=-0.058
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y4
v4
vin
a4
q4"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 3825 -2578.75 4625 -2178.75 {flags=graph
y1=-0.056
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6 8 21"
node="y5
v5
vin
a5
q5"}
B 2 3825 -2978.75 4625 -2578.75 {flags=graph
y1=-0.055
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y6
v6
vin
a6
q6"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 3825 -3378.75 4625 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y7
v7
vin
a7
q7"}
B 2 3825 -3778.75 4625 -3378.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y8
v8
vin
a8
q8"}
B 2 4625 -2578.75 5425 -2178.75 {flags=graph
y1=-0.06
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y9
v9
vin
a9
q9"}
B 2 4625 -2978.75 5425 -2578.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 5 6 8 21"
node="y10
v10
vin
a10
q10"}
B 2 4625 -3378.75 5425 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y11
v11
vin
a11
q11"}
B 2 4625 -3778.75 5425 -3378.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y12
v12
vin
a12
q12"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 5425 -2578.75 6225 -2178.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6 8 21"
node="y13
v13
vin
a13
q13"}
B 2 5425 -2978.75 6225 -2578.75 {flags=graph
y1=-0.056
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y14
v14
vin
a14
q14"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 5425 -3378.75 6225 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y15
v15
vin
a15
q15"}
B 2 5425 -3778.75 6225 -3378.75 {flags=graph
y1=-0.062
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y16
v16
vin
a16
q16"}
B 2 3825 -2178.75 4625 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 4625 -2178.75 5425 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 5425 -2178.75 6225 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 3040 -1686.25 3840 -1286.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=7
node=out3}
B 2 3040 -1286.25 3840 -886.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=21
node=out2}
B 2 3840 -1686.25 4640 -1286.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=8
node=out1}
B 2 3840 -1286.25 4640 -886.25 {flags=graph
y1=-0.0058
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=12
node=out0}
B 2 3840 -886.25 4638.75 -443.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk
hilight_wave=0}
B 2 3041.25 -886.25 3840 -443.75 {flags=graph
y1=0.49
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


hilight_wave=0
color=10
node=vin}
B 2 5111.25 -1463.75 5911.25 -1063.75 {flags=graph
y1=-0.056
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6"
node="y5
q5
out0"}
N 593.75 -901.25 593.75 -881.25 {
lab=V2}
N 593.75 -801.25 593.75 -781.25 {
lab=V1}
N 593.75 -701.25 593.75 -681.25 {
lab=#net1}
N 593.75 -1001.25 593.75 -981.25 {
lab=V3}
N 593.75 -1101.25 593.75 -1081.25 {
lab=V4}
N 593.75 -1201.25 593.75 -1181.25 {
lab=V5}
N 593.75 -1301.25 593.75 -1281.25 {
lab=V6}
N 593.75 -1401.25 593.75 -1381.25 {
lab=V7}
N 593.75 -1501.25 593.75 -1481.25 {
lab=V8}
N 593.75 -1601.25 593.75 -1581.25 {
lab=V9}
N 593.75 -1701.25 593.75 -1681.25 {
lab=V10}
N 593.75 -1801.25 593.75 -1781.25 {
lab=V11}
N 593.75 -1901.25 593.75 -1881.25 {
lab=V12}
N 593.75 -2001.25 593.75 -1981.25 {
lab=V13}
N 593.75 -2101.25 593.75 -2081.25 {
lab=V14}
N 593.75 -2201.25 593.75 -2181.25 {
lab=V15}
N 593.75 -2301.25 593.75 -2281.25 {
lab=V16}
N 533.75 -2251.25 573.75 -2251.25 {
lab=#net1}
N 533.75 -2251.25 533.75 -2151.25 {
lab=#net1}
N 533.75 -2151.25 573.75 -2151.25 {
lab=#net1}
N 533.75 -2051.25 573.75 -2051.25 {
lab=#net1}
N 533.75 -1951.25 573.75 -1951.25 {
lab=#net1}
N 533.75 -1851.25 573.75 -1851.25 {
lab=#net1}
N 533.75 -1751.25 573.75 -1751.25 {
lab=#net1}
N 533.75 -1651.25 573.75 -1651.25 {
lab=#net1}
N 533.75 -1551.25 573.75 -1551.25 {
lab=#net1}
N 533.75 -1451.25 573.75 -1451.25 {
lab=#net1}
N 533.75 -1351.25 573.75 -1351.25 {
lab=#net1}
N 533.75 -1251.25 573.75 -1251.25 {
lab=#net1}
N 533.75 -1151.25 573.75 -1151.25 {
lab=#net1}
N 533.75 -1051.25 573.75 -1051.25 {
lab=#net1}
N 533.75 -951.25 573.75 -951.25 {
lab=#net1}
N 533.75 -851.25 573.75 -851.25 {
lab=#net1}
N 533.75 -751.25 573.75 -751.25 {
lab=#net1}
N 533.75 -701.25 593.75 -701.25 {
lab=#net1}
N 533.75 -751.25 533.75 -701.25 {
lab=#net1}
N 533.75 -951.25 533.75 -851.25 {
lab=#net1}
N 533.75 -1051.25 533.75 -951.25 {
lab=#net1}
N 593.75 -421.25 593.75 -381.25 {
lab=#net2}
N 593.75 -321.25 593.75 -281.25 {
lab=GND}
N 753.75 -421.25 753.75 -381.25 {
lab=CLK}
N 753.75 -321.25 753.75 -281.25 {
lab=GND}
N 593.75 -121.25 623.75 -121.25 {
lab=VDD}
N 593.75 -61.25 593.75 -21.25 {
lab=GND}
N 753.75 -161.25 753.75 -121.25 {
lab=VFS}
N 753.75 -61.25 753.75 -21.25 {
lab=GND}
N 593.75 -521.25 593.75 -481.25 {
lab=V_IGNORE}
N 593.75 -801.25 813.75 -801.25 {
lab=V1}
N 593.75 -2421.25 593.75 -2381.25 {
lab=VFS}
N 533.75 -2351.25 573.75 -2351.25 {
lab=#net1}
N 533.75 -2351.25 533.75 -2251.25 {
lab=#net1}
N 773.75 -761.25 813.75 -761.25 {
lab=IB}
N 773.75 -781.25 813.75 -781.25 {
lab=VIN}
N 1113.75 -801.25 1153.75 -801.25 {
lab=VDD}
N 1113.75 -781.25 1223.75 -781.25 {
lab=Y1}
N 1113.75 -761.25 1223.75 -761.25 {
lab=X1}
N 1113.75 -741.25 1153.75 -741.25 {
lab=GND}
N 1113.75 -901.25 1153.75 -901.25 {
lab=VDD}
N 1113.75 -881.25 1223.75 -881.25 {
lab=Y2}
N 1113.75 -861.25 1223.75 -861.25 {
lab=X2}
N 1113.75 -841.25 1153.75 -841.25 {
lab=GND}
N 1113.75 -1001.25 1153.75 -1001.25 {
lab=VDD}
N 1113.75 -981.25 1223.75 -981.25 {
lab=Y3}
N 1113.75 -961.25 1223.75 -961.25 {
lab=X3}
N 1113.75 -941.25 1153.75 -941.25 {
lab=GND}
N 1113.75 -1101.25 1153.75 -1101.25 {
lab=VDD}
N 1113.75 -1081.25 1223.75 -1081.25 {
lab=Y4}
N 1113.75 -1061.25 1223.75 -1061.25 {
lab=X4}
N 1113.75 -1041.25 1153.75 -1041.25 {
lab=GND}
N 1113.75 -1201.25 1153.75 -1201.25 {
lab=VDD}
N 1113.75 -1181.25 1223.75 -1181.25 {
lab=Y5}
N 1113.75 -1161.25 1223.75 -1161.25 {
lab=X5}
N 1113.75 -1141.25 1153.75 -1141.25 {
lab=GND}
N 1113.75 -1301.25 1153.75 -1301.25 {
lab=VDD}
N 1113.75 -1281.25 1223.75 -1281.25 {
lab=Y6}
N 1113.75 -1261.25 1223.75 -1261.25 {
lab=X6}
N 1113.75 -1241.25 1153.75 -1241.25 {
lab=GND}
N 1113.75 -1401.25 1153.75 -1401.25 {
lab=VDD}
N 1113.75 -1381.25 1223.75 -1381.25 {
lab=Y7}
N 1113.75 -1361.25 1223.75 -1361.25 {
lab=X7}
N 1113.75 -1341.25 1153.75 -1341.25 {
lab=GND}
N 1113.75 -1501.25 1153.75 -1501.25 {
lab=VDD}
N 1113.75 -1481.25 1223.75 -1481.25 {
lab=Y8}
N 1113.75 -1461.25 1223.75 -1461.25 {
lab=X8}
N 1113.75 -1441.25 1153.75 -1441.25 {
lab=GND}
N 1113.75 -1601.25 1153.75 -1601.25 {
lab=VDD}
N 1113.75 -1581.25 1223.75 -1581.25 {
lab=Y9}
N 1113.75 -1561.25 1223.75 -1561.25 {
lab=X9}
N 1113.75 -1541.25 1153.75 -1541.25 {
lab=GND}
N 1113.75 -1701.25 1153.75 -1701.25 {
lab=VDD}
N 1113.75 -1681.25 1223.75 -1681.25 {
lab=Y10}
N 1113.75 -1661.25 1223.75 -1661.25 {
lab=X10}
N 1113.75 -1641.25 1153.75 -1641.25 {
lab=GND}
N 1113.75 -1801.25 1153.75 -1801.25 {
lab=VDD}
N 1113.75 -1781.25 1223.75 -1781.25 {
lab=Y11}
N 1113.75 -1761.25 1223.75 -1761.25 {
lab=X11}
N 1113.75 -1741.25 1153.75 -1741.25 {
lab=GND}
N 1113.75 -1901.25 1153.75 -1901.25 {
lab=VDD}
N 1113.75 -1881.25 1223.75 -1881.25 {
lab=Y12}
N 1113.75 -1861.25 1223.75 -1861.25 {
lab=X12}
N 1113.75 -1841.25 1153.75 -1841.25 {
lab=GND}
N 1113.75 -2001.25 1153.75 -2001.25 {
lab=VDD}
N 1113.75 -1981.25 1223.75 -1981.25 {
lab=Y13}
N 1113.75 -1961.25 1223.75 -1961.25 {
lab=X13}
N 1113.75 -1941.25 1153.75 -1941.25 {
lab=GND}
N 1113.75 -2101.25 1153.75 -2101.25 {
lab=VDD}
N 1113.75 -2081.25 1223.75 -2081.25 {
lab=Y14}
N 1113.75 -2061.25 1223.75 -2061.25 {
lab=X14}
N 1113.75 -2041.25 1153.75 -2041.25 {
lab=GND}
N 1113.75 -2201.25 1153.75 -2201.25 {
lab=VDD}
N 1113.75 -2181.25 1223.75 -2181.25 {
lab=Y15}
N 1113.75 -2161.25 1223.75 -2161.25 {
lab=X15}
N 1113.75 -2141.25 1153.75 -2141.25 {
lab=GND}
N 1113.75 -2301.25 1153.75 -2301.25 {
lab=VDD}
N 1113.75 -2281.25 1223.75 -2281.25 {
lab=Y16}
N 1113.75 -2261.25 1223.75 -2261.25 {
lab=X16}
N 1113.75 -2241.25 1153.75 -2241.25 {
lab=GND}
N 913.75 -161.25 913.75 -121.25 {
lab=VDD}
N 913.75 -61.25 913.75 -21.25 {
lab=IB}
N 593.75 -621.25 593.75 -601.25 {
lab=GND}
N 373.75 -921.25 373.75 -881.25 {
lab=A2}
N 373.75 -821.25 373.75 -781.25 {
lab=A1}
N 373.75 -701.25 373.75 -681.25 {
lab=#net3}
N 373.75 -1021.25 373.75 -981.25 {
lab=A3}
N 373.75 -1121.25 373.75 -1081.25 {
lab=A4}
N 373.75 -1221.25 373.75 -1181.25 {
lab=A5}
N 373.75 -1321.25 373.75 -1281.25 {
lab=A6}
N 373.75 -1421.25 373.75 -1381.25 {
lab=A7}
N 373.75 -1521.25 373.75 -1481.25 {
lab=A8}
N 373.75 -1621.25 373.75 -1581.25 {
lab=A9}
N 373.75 -1721.25 373.75 -1681.25 {
lab=A10}
N 373.75 -1821.25 373.75 -1781.25 {
lab=A11}
N 373.75 -1921.25 373.75 -1881.25 {
lab=A12}
N 373.75 -2021.25 373.75 -1981.25 {
lab=A13}
N 373.75 -2121.25 373.75 -2081.25 {
lab=A14}
N 373.75 -2221.25 373.75 -2181.25 {
lab=A15}
N 373.75 -2321.25 373.75 -2281.25 {
lab=A16}
N 313.75 -2251.25 353.75 -2251.25 {
lab=#net3}
N 313.75 -2251.25 313.75 -2151.25 {
lab=#net3}
N 313.75 -2151.25 353.75 -2151.25 {
lab=#net3}
N 313.75 -2051.25 353.75 -2051.25 {
lab=#net3}
N 313.75 -1951.25 353.75 -1951.25 {
lab=#net3}
N 313.75 -1851.25 353.75 -1851.25 {
lab=#net3}
N 313.75 -1751.25 353.75 -1751.25 {
lab=#net3}
N 313.75 -1651.25 353.75 -1651.25 {
lab=#net3}
N 313.75 -1551.25 353.75 -1551.25 {
lab=#net3}
N 313.75 -1451.25 353.75 -1451.25 {
lab=#net3}
N 313.75 -1351.25 353.75 -1351.25 {
lab=#net3}
N 313.75 -1251.25 353.75 -1251.25 {
lab=#net3}
N 313.75 -1151.25 353.75 -1151.25 {
lab=#net3}
N 313.75 -1051.25 353.75 -1051.25 {
lab=#net3}
N 313.75 -951.25 353.75 -951.25 {
lab=#net3}
N 313.75 -851.25 353.75 -851.25 {
lab=#net3}
N 313.75 -751.25 353.75 -751.25 {
lab=#net3}
N 313.75 -701.25 373.75 -701.25 {
lab=#net3}
N 313.75 -751.25 313.75 -701.25 {
lab=#net3}
N 313.75 -951.25 313.75 -851.25 {
lab=#net3}
N 313.75 -1051.25 313.75 -951.25 {
lab=#net3}
N 373.75 -2421.25 373.75 -2381.25 {
lab=VFS}
N 313.75 -2351.25 353.75 -2351.25 {
lab=#net3}
N 313.75 -2351.25 313.75 -2251.25 {
lab=#net3}
N 373.75 -621.25 373.75 -601.25 {
lab=GND}
N 773.75 -741.25 813.75 -741.25 {
lab=CLK}
N 593.75 -901.25 813.75 -901.25 {
lab=V2}
N 773.75 -861.25 813.75 -861.25 {
lab=IB}
N 773.75 -881.25 813.75 -881.25 {
lab=VIN}
N 773.75 -841.25 813.75 -841.25 {
lab=CLK}
N 593.75 -1001.25 813.75 -1001.25 {
lab=V3}
N 773.75 -961.25 813.75 -961.25 {
lab=IB}
N 773.75 -981.25 813.75 -981.25 {
lab=VIN}
N 773.75 -941.25 813.75 -941.25 {
lab=CLK}
N 593.75 -1101.25 813.75 -1101.25 {
lab=V4}
N 773.75 -1061.25 813.75 -1061.25 {
lab=IB}
N 773.75 -1081.25 813.75 -1081.25 {
lab=VIN}
N 773.75 -1041.25 813.75 -1041.25 {
lab=CLK}
N 593.75 -1201.25 813.75 -1201.25 {
lab=V5}
N 773.75 -1161.25 813.75 -1161.25 {
lab=IB}
N 773.75 -1181.25 813.75 -1181.25 {
lab=VIN}
N 773.75 -1141.25 813.75 -1141.25 {
lab=CLK}
N 593.75 -1301.25 813.75 -1301.25 {
lab=V6}
N 773.75 -1261.25 813.75 -1261.25 {
lab=IB}
N 773.75 -1281.25 813.75 -1281.25 {
lab=VIN}
N 773.75 -1241.25 813.75 -1241.25 {
lab=CLK}
N 593.75 -1401.25 813.75 -1401.25 {
lab=V7}
N 773.75 -1361.25 813.75 -1361.25 {
lab=IB}
N 773.75 -1381.25 813.75 -1381.25 {
lab=VIN}
N 773.75 -1341.25 813.75 -1341.25 {
lab=CLK}
N 593.75 -1501.25 813.75 -1501.25 {
lab=V8}
N 773.75 -1461.25 813.75 -1461.25 {
lab=IB}
N 773.75 -1481.25 813.75 -1481.25 {
lab=VIN}
N 773.75 -1441.25 813.75 -1441.25 {
lab=CLK}
N 593.75 -1601.25 813.75 -1601.25 {
lab=V9}
N 773.75 -1561.25 813.75 -1561.25 {
lab=IB}
N 773.75 -1581.25 813.75 -1581.25 {
lab=VIN}
N 773.75 -1541.25 813.75 -1541.25 {
lab=CLK}
N 593.75 -1701.25 813.75 -1701.25 {
lab=V10}
N 773.75 -1661.25 813.75 -1661.25 {
lab=IB}
N 773.75 -1681.25 813.75 -1681.25 {
lab=VIN}
N 773.75 -1641.25 813.75 -1641.25 {
lab=CLK}
N 593.75 -1801.25 813.75 -1801.25 {
lab=V11}
N 773.75 -1761.25 813.75 -1761.25 {
lab=IB}
N 773.75 -1781.25 813.75 -1781.25 {
lab=VIN}
N 773.75 -1741.25 813.75 -1741.25 {
lab=CLK}
N 593.75 -1901.25 813.75 -1901.25 {
lab=V12}
N 773.75 -1861.25 813.75 -1861.25 {
lab=IB}
N 773.75 -1881.25 813.75 -1881.25 {
lab=VIN}
N 773.75 -1841.25 813.75 -1841.25 {
lab=CLK}
N 593.75 -2001.25 813.75 -2001.25 {
lab=V13}
N 773.75 -1961.25 813.75 -1961.25 {
lab=IB}
N 773.75 -1981.25 813.75 -1981.25 {
lab=VIN}
N 773.75 -1941.25 813.75 -1941.25 {
lab=CLK}
N 593.75 -2101.25 813.75 -2101.25 {
lab=V14}
N 773.75 -2061.25 813.75 -2061.25 {
lab=IB}
N 773.75 -2081.25 813.75 -2081.25 {
lab=VIN}
N 773.75 -2041.25 813.75 -2041.25 {
lab=CLK}
N 593.75 -2201.25 813.75 -2201.25 {
lab=V15}
N 773.75 -2161.25 813.75 -2161.25 {
lab=IB}
N 773.75 -2181.25 813.75 -2181.25 {
lab=VIN}
N 773.75 -2141.25 813.75 -2141.25 {
lab=CLK}
N 593.75 -2301.25 813.75 -2301.25 {
lab=V16}
N 773.75 -2261.25 813.75 -2261.25 {
lab=IB}
N 773.75 -2281.25 813.75 -2281.25 {
lab=VIN}
N 773.75 -2241.25 813.75 -2241.25 {
lab=CLK}
N 373.75 -421.25 373.75 -381.25 {
lab=#net4}
N 373.75 -321.25 373.75 -281.25 {
lab=GND}
N 373.75 -521.25 373.75 -481.25 {
lab=VIN}
N 533.75 -2151.25 533.75 -2051.25 {
lab=#net1}
N 533.75 -2051.25 533.75 -1951.25 {
lab=#net1}
N 533.75 -1951.25 533.75 -1851.25 {
lab=#net1}
N 533.75 -1851.25 533.75 -1751.25 {
lab=#net1}
N 533.75 -1751.25 533.75 -1651.25 {
lab=#net1}
N 533.75 -1651.25 533.75 -1551.25 {
lab=#net1}
N 533.75 -1551.25 533.75 -1451.25 {
lab=#net1}
N 533.75 -1451.25 533.75 -1351.25 {
lab=#net1}
N 533.75 -1351.25 533.75 -1251.25 {
lab=#net1}
N 533.75 -1251.25 533.75 -1151.25 {
lab=#net1}
N 533.75 -1151.25 533.75 -1051.25 {
lab=#net1}
N 533.75 -851.25 533.75 -751.25 {
lab=#net1}
N 593.75 -721.25 593.75 -701.25 {
lab=#net1}
N 593.75 -821.25 593.75 -801.25 {
lab=V1}
N 313.75 -2151.25 313.75 -2051.25 {
lab=#net3}
N 313.75 -2051.25 313.75 -1951.25 {
lab=#net3}
N 313.75 -1951.25 313.75 -1851.25 {
lab=#net3}
N 313.75 -1851.25 313.75 -1751.25 {
lab=#net3}
N 313.75 -1751.25 313.75 -1651.25 {
lab=#net3}
N 313.75 -1651.25 313.75 -1551.25 {
lab=#net3}
N 313.75 -1551.25 313.75 -1451.25 {
lab=#net3}
N 313.75 -1451.25 313.75 -1351.25 {
lab=#net3}
N 313.75 -1351.25 313.75 -1251.25 {
lab=#net3}
N 313.75 -1251.25 313.75 -1151.25 {
lab=#net3}
N 313.75 -1151.25 313.75 -1051.25 {
lab=#net3}
N 313.75 -851.25 313.75 -751.25 {
lab=#net3}
N 373.75 -721.25 373.75 -701.25 {
lab=#net3}
N 593.75 -921.25 593.75 -901.25 {
lab=V2}
N 593.75 -1021.25 593.75 -1001.25 {
lab=V3}
N 593.75 -1121.25 593.75 -1101.25 {
lab=V4}
N 593.75 -1221.25 593.75 -1201.25 {
lab=V5}
N 593.75 -1321.25 593.75 -1301.25 {
lab=V6}
N 593.75 -1421.25 593.75 -1401.25 {
lab=V7}
N 593.75 -1521.25 593.75 -1501.25 {
lab=V8}
N 593.75 -1621.25 593.75 -1601.25 {
lab=V9}
N 593.75 -1721.25 593.75 -1701.25 {
lab=V10}
N 593.75 -1821.25 593.75 -1801.25 {
lab=V11}
N 593.75 -1921.25 593.75 -1901.25 {
lab=V12}
N 593.75 -2021.25 593.75 -2001.25 {
lab=V13}
N 593.75 -2121.25 593.75 -2101.25 {
lab=V14}
N 593.75 -2221.25 593.75 -2201.25 {
lab=V15}
N 593.75 -2321.25 593.75 -2301.25 {
lab=V16}
N 1872.5 -1711.25 1872.5 -1661.25 {
lab=Q10}
N 1892.5 -1691.25 1892.5 -1561.25 {
lab=Q9}
N 1912.5 -1671.25 1912.5 -1461.25 {
lab=Q8}
N 1922.5 -1651.25 1922.5 -1361.25 {
lab=Q7}
N 1942.5 -1631.25 1942.5 -1261.25 {
lab=Q6}
N 1962.5 -1611.25 1962.5 -1161.25 {
lab=Q5}
N 1972.5 -1591.25 1972.5 -1061.25 {
lab=Q4}
N 1982.5 -1561.25 1982.5 -961.25 {
lab=Q3}
N 1982.5 -1571.25 1982.5 -1561.25 {
lab=Q3}
N 1992.5 -1551.25 1992.5 -861.25 {
lab=Q2}
N 2002.5 -1531.25 2002.5 -761.25 {
lab=Q1}
N 1602.5 -2261.25 1963.75 -2261.25 {
lab=Q16}
N 1963.75 -2261.25 1963.75 -2241.25 {
lab=Q16}
N 1602.5 -2161.25 1942.5 -2161.25 {
lab=Q15}
N 1942.5 -2161.25 1942.5 -2141.25 {
lab=Q15}
N 1602.5 -2061.25 1922.5 -2061.25 {
lab=Q14}
N 1922.5 -2061.25 1922.5 -2041.25 {
lab=Q14}
N 1602.5 -1961.25 1902.5 -1961.25 {
lab=Q13}
N 1902.5 -1961.25 1902.5 -1942.5 {
lab=Q13}
N 1602.5 -1861.25 1882.5 -1861.25 {
lab=Q12}
N 1882.5 -1861.25 1882.5 -1841.25 {
lab=Q12}
N 1602.5 -1761.25 1862.5 -1761.25 {
lab=Q11}
N 1862.5 -1761.25 1862.5 -1741.25 {
lab=Q11}
N 1602.5 -1661.25 1872.5 -1661.25 {
lab=Q10}
N 1602.5 -1561.25 1892.5 -1561.25 {
lab=Q9}
N 1602.5 -1461.25 1912.5 -1461.25 {
lab=Q8}
N 1602.5 -1361.25 1922.5 -1361.25 {
lab=Q7}
N 1602.5 -1261.25 1942.5 -1261.25 {
lab=Q6}
N 1602.5 -1161.25 1962.5 -1161.25 {
lab=Q5}
N 1602.5 -1061.25 1972.5 -1061.25 {
lab=Q4}
N 1602.5 -961.25 1982.5 -961.25 {
lab=Q3}
N 1602.5 -861.25 1992.5 -861.25 {
lab=Q2}
N 1602.5 -761.25 2002.5 -761.25 {
lab=Q1}
N 463.75 -42.5 463.75 -12.5 {
lab=GND}
N 2002.5 -1532.5 2002.5 -1531.25 {
lab=Q1}
N 2002.5 -1532.5 2145 -1532.5 {
lab=Q1}
N 1992.5 -1552.5 1992.5 -1551.25 {
lab=Q2}
N 1992.5 -1552.5 2143.75 -1552.5 {
lab=Q2}
N 1982.5 -1572.5 1982.5 -1571.25 {
lab=Q3}
N 1982.5 -1572.5 2143.75 -1572.5 {
lab=Q3}
N 1972.5 -1592.5 1972.5 -1591.25 {
lab=Q4}
N 1972.5 -1592.5 2145 -1592.5 {
lab=Q4}
N 1962.5 -1612.5 1962.5 -1611.25 {
lab=Q5}
N 1962.5 -1612.5 2143.75 -1612.5 {
lab=Q5}
N 1942.5 -1632.5 1942.5 -1631.25 {
lab=Q6}
N 1942.5 -1632.5 2143.75 -1632.5 {
lab=Q6}
N 1922.5 -1652.5 1922.5 -1651.25 {
lab=Q7}
N 1922.5 -1652.5 2145 -1652.5 {
lab=Q7}
N 1912.5 -1672.5 1912.5 -1671.25 {
lab=Q8}
N 1912.5 -1672.5 2143.75 -1672.5 {
lab=Q8}
N 1892.5 -1692.5 2143.75 -1692.5 {
lab=Q9}
N 1892.5 -1692.5 1892.5 -1691.25 {
lab=Q9}
N 1872.5 -1712.5 2143.75 -1712.5 {
lab=Q10}
N 1872.5 -1712.5 1872.5 -1711.25 {
lab=Q10}
N 1862.5 -1732.5 2143.75 -1732.5 {
lab=Q11}
N 1862.5 -1741.25 1862.5 -1732.5 {
lab=Q11}
N 1882.5 -1752.5 2143.75 -1752.5 {
lab=Q12}
N 1882.5 -1841.25 1882.5 -1752.5 {
lab=Q12}
N 1902.5 -1772.5 2143.75 -1772.5 {
lab=Q13}
N 1902.5 -1942.5 1902.5 -1772.5 {
lab=Q13}
N 1922.5 -2041.25 1922.5 -1792.5 {
lab=Q14}
N 1922.5 -1792.5 2143.75 -1792.5 {
lab=Q14}
N 1942.5 -2141.25 1942.5 -1812.5 {
lab=Q15}
N 1942.5 -1812.5 2143.75 -1812.5 {
lab=Q15}
N 1963.75 -2241.25 1963.75 -1832.5 {
lab=Q16}
N 1963.75 -1832.5 2146.25 -1832.5 {
lab=Q16}
C {devices/vsource.sym} 593.75 -351.25 0 0 {name=V3 value="sin(1.1 0.5 12.5MEG)" savecurrent=false}
C {devices/gnd.sym} 593.75 -281.25 0 0 {name=l34 lab=GND}
C {devices/lab_pin.sym} 593.75 -521.25 2 0 {name=p196 sig_type=std_logic lab=V_IGNORE}
C {devices/vsource.sym} 753.75 -351.25 0 0 {name=V4 value="pulse(0 1.8 8ns 1ns 1ns 20ns 40ns)" savecurrent=false}
C {devices/gnd.sym} 753.75 -281.25 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 753.75 -421.25 2 0 {name=p197 sig_type=std_logic lab=CLK}
C {devices/vsource.sym} 593.75 -91.25 0 0 {name=V1 value=1.8 savecurrent=false}
C {devices/gnd.sym} 593.75 -21.25 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 623.75 -121.25 2 0 {name=p198 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 753.75 -91.25 0 0 {name=V2 value=1.6 savecurrent=false}
C {devices/gnd.sym} 753.75 -21.25 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} 753.75 -161.25 2 0 {name=p199 sig_type=std_logic lab=VFS}
C {devices/res.sym} 593.75 -451.25 0 0 {name=R17
value=1k
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} 593.75 -2421.25 2 1 {name=p1 sig_type=std_logic lab=VFS}
C {devices/lab_pin.sym} 773.75 -761.25 2 1 {name=p40 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -741.25 2 1 {name=p41 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -781.25 2 1 {name=p49 sig_type=std_logic lab=VIN}
C {devices/gnd.sym} 1153.75 -741.25 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 1153.75 -801.25 2 0 {name=p50 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -781.25 2 0 {name=p51 sig_type=std_logic lab=Y1}
C {devices/lab_pin.sym} 1153.75 -761.25 2 0 {name=p52 sig_type=std_logic lab=X1}
C {devices/gnd.sym} 1153.75 -841.25 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 1153.75 -901.25 2 0 {name=p53 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -881.25 2 0 {name=p54 sig_type=std_logic lab=Y2}
C {devices/lab_pin.sym} 1153.75 -861.25 2 0 {name=p55 sig_type=std_logic lab=X2}
C {devices/gnd.sym} 1153.75 -941.25 0 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1001.25 2 0 {name=p56 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -981.25 2 0 {name=p57 sig_type=std_logic lab=Y3}
C {devices/lab_pin.sym} 1153.75 -961.25 2 0 {name=p58 sig_type=std_logic lab=X3}
C {devices/gnd.sym} 1153.75 -1041.25 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1101.25 2 0 {name=p59 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1081.25 2 0 {name=p60 sig_type=std_logic lab=Y4}
C {devices/lab_pin.sym} 1153.75 -1061.25 2 0 {name=p61 sig_type=std_logic lab=X4}
C {devices/gnd.sym} 1153.75 -1141.25 0 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1201.25 2 0 {name=p62 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1181.25 2 0 {name=p63 sig_type=std_logic lab=Y5}
C {devices/lab_pin.sym} 1153.75 -1161.25 2 0 {name=p64 sig_type=std_logic lab=X5}
C {devices/gnd.sym} 1153.75 -1241.25 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1301.25 2 0 {name=p65 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1281.25 2 0 {name=p66 sig_type=std_logic lab=Y6}
C {devices/lab_pin.sym} 1153.75 -1261.25 2 0 {name=p67 sig_type=std_logic lab=X6}
C {devices/gnd.sym} 1153.75 -1341.25 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1401.25 2 0 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1381.25 2 0 {name=p69 sig_type=std_logic lab=Y7}
C {devices/lab_pin.sym} 1153.75 -1361.25 2 0 {name=p70 sig_type=std_logic lab=X7}
C {devices/gnd.sym} 1153.75 -1441.25 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1501.25 2 0 {name=p71 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1481.25 2 0 {name=p72 sig_type=std_logic lab=Y8}
C {devices/lab_pin.sym} 1153.75 -1461.25 2 0 {name=p73 sig_type=std_logic lab=X8}
C {devices/gnd.sym} 1153.75 -1541.25 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1601.25 2 0 {name=p74 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1581.25 2 0 {name=p75 sig_type=std_logic lab=Y9}
C {devices/lab_pin.sym} 1153.75 -1561.25 2 0 {name=p76 sig_type=std_logic lab=X9}
C {devices/gnd.sym} 1153.75 -1641.25 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1701.25 2 0 {name=p77 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1681.25 2 0 {name=p78 sig_type=std_logic lab=Y10}
C {devices/lab_pin.sym} 1153.75 -1661.25 2 0 {name=p79 sig_type=std_logic lab=X10}
C {devices/gnd.sym} 1153.75 -1741.25 0 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1801.25 2 0 {name=p80 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1781.25 2 0 {name=p81 sig_type=std_logic lab=Y11}
C {devices/lab_pin.sym} 1153.75 -1761.25 2 0 {name=p82 sig_type=std_logic lab=X11}
C {devices/gnd.sym} 1153.75 -1841.25 0 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 1153.75 -1901.25 2 0 {name=p83 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1881.25 2 0 {name=p84 sig_type=std_logic lab=Y12}
C {devices/lab_pin.sym} 1153.75 -1861.25 2 0 {name=p85 sig_type=std_logic lab=X12}
C {devices/gnd.sym} 1153.75 -1941.25 0 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 1153.75 -2001.25 2 0 {name=p86 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -1981.25 2 0 {name=p87 sig_type=std_logic lab=Y13}
C {devices/lab_pin.sym} 1153.75 -1961.25 2 0 {name=p88 sig_type=std_logic lab=X13}
C {devices/gnd.sym} 1153.75 -2041.25 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} 1153.75 -2101.25 2 0 {name=p89 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -2081.25 2 0 {name=p90 sig_type=std_logic lab=Y14}
C {devices/lab_pin.sym} 1153.75 -2061.25 2 0 {name=p91 sig_type=std_logic lab=X14}
C {devices/gnd.sym} 1153.75 -2141.25 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 1153.75 -2201.25 2 0 {name=p92 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -2181.25 2 0 {name=p93 sig_type=std_logic lab=Y15}
C {devices/lab_pin.sym} 1153.75 -2161.25 2 0 {name=p94 sig_type=std_logic lab=X15}
C {devices/gnd.sym} 1153.75 -2241.25 0 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} 1153.75 -2301.25 2 0 {name=p95 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1153.75 -2281.25 2 0 {name=p96 sig_type=std_logic lab=Y16}
C {devices/lab_pin.sym} 1153.75 -2261.25 2 0 {name=p97 sig_type=std_logic lab=X16}
C {devices/lab_pin.sym} 593.75 -801.25 2 1 {name=p98 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 593.75 -901.25 2 1 {name=p99 sig_type=std_logic lab=V2}
C {devices/lab_pin.sym} 593.75 -1001.25 2 1 {name=p100 sig_type=std_logic lab=V3}
C {devices/lab_pin.sym} 593.75 -1101.25 2 1 {name=p101 sig_type=std_logic lab=V4}
C {devices/lab_pin.sym} 593.75 -1201.25 2 1 {name=p102 sig_type=std_logic lab=V5}
C {devices/lab_pin.sym} 593.75 -1301.25 2 1 {name=p103 sig_type=std_logic lab=V6}
C {devices/lab_pin.sym} 593.75 -1401.25 2 1 {name=p104 sig_type=std_logic lab=V7}
C {devices/lab_pin.sym} 593.75 -1501.25 2 1 {name=p105 sig_type=std_logic lab=V8}
C {devices/lab_pin.sym} 593.75 -1601.25 2 1 {name=p106 sig_type=std_logic lab=V9}
C {devices/lab_pin.sym} 593.75 -1701.25 2 1 {name=p107 sig_type=std_logic lab=V10}
C {devices/lab_pin.sym} 593.75 -1801.25 2 1 {name=p108 sig_type=std_logic lab=V11}
C {devices/lab_pin.sym} 593.75 -1901.25 2 1 {name=p109 sig_type=std_logic lab=V12}
C {devices/lab_pin.sym} 593.75 -2001.25 2 1 {name=p110 sig_type=std_logic lab=V13}
C {devices/lab_pin.sym} 593.75 -2101.25 2 1 {name=p111 sig_type=std_logic lab=V14}
C {devices/lab_pin.sym} 593.75 -2201.25 2 1 {name=p112 sig_type=std_logic lab=V15}
C {devices/lab_pin.sym} 593.75 -2301.25 2 1 {name=p113 sig_type=std_logic lab=V16}
C {devices/code_shown.sym} 1203.75 -221.25 0 0 {name=COMMANDS only_toplevel=false value=
"
.options savecurrents
.control

save all

tran 0.005n 240n
write flashADC_Testing_v0p4p3.raw

.endc
"}
C {devices/isource.sym} 913.75 -91.25 0 0 {name=I0 value=160u}
C {devices/lab_pin.sym} 913.75 -161.25 2 0 {name=p114 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 913.75 -21.25 2 0 {name=p115 sig_type=std_logic lab=IB}
C {devices/vsource.sym} 593.75 -651.25 0 0 {name=V5 value=0.6 savecurrent=false}
C {devices/gnd.sym} 593.75 -601.25 0 0 {name=l2 lab=GND}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -751.25 0 0 {name=R19
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {devices/lab_pin.sym} 373.75 -2421.25 2 1 {name=p116 sig_type=std_logic lab=VFS}
C {devices/lab_pin.sym} 373.75 -801.25 2 1 {name=p117 sig_type=std_logic lab=A1}
C {devices/lab_pin.sym} 373.75 -901.25 2 1 {name=p118 sig_type=std_logic lab=A2}
C {devices/lab_pin.sym} 373.75 -1001.25 2 1 {name=p119 sig_type=std_logic lab=A3}
C {devices/lab_pin.sym} 373.75 -1101.25 2 1 {name=p120 sig_type=std_logic lab=A4}
C {devices/lab_pin.sym} 373.75 -1201.25 2 1 {name=p121 sig_type=std_logic lab=A5}
C {devices/lab_pin.sym} 373.75 -1301.25 2 1 {name=p122 sig_type=std_logic lab=A6}
C {devices/lab_pin.sym} 373.75 -1401.25 2 1 {name=p123 sig_type=std_logic lab=A7}
C {devices/lab_pin.sym} 373.75 -1501.25 2 1 {name=p124 sig_type=std_logic lab=A8}
C {devices/lab_pin.sym} 373.75 -1601.25 2 1 {name=p125 sig_type=std_logic lab=A9}
C {devices/lab_pin.sym} 373.75 -1701.25 2 1 {name=p126 sig_type=std_logic lab=A10}
C {devices/lab_pin.sym} 373.75 -1801.25 2 1 {name=p127 sig_type=std_logic lab=A11}
C {devices/lab_pin.sym} 373.75 -1901.25 2 1 {name=p128 sig_type=std_logic lab=A12}
C {devices/lab_pin.sym} 373.75 -2001.25 2 1 {name=p129 sig_type=std_logic lab=A13}
C {devices/lab_pin.sym} 373.75 -2101.25 2 1 {name=p130 sig_type=std_logic lab=A14}
C {devices/lab_pin.sym} 373.75 -2201.25 2 1 {name=p131 sig_type=std_logic lab=A15}
C {devices/lab_pin.sym} 373.75 -2301.25 2 1 {name=p132 sig_type=std_logic lab=A16}
C {devices/vsource.sym} 373.75 -651.25 0 0 {name=V6 value=0.6 savecurrent=false}
C {devices/gnd.sym} 373.75 -601.25 0 0 {name=l18 lab=GND}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -851.25 0 0 {name=R20
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -951.25 0 0 {name=R21
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1051.25 0 0 {name=R22
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1151.25 0 0 {name=R23
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1251.25 0 0 {name=R24
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1351.25 0 0 {name=R25
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1451.25 0 0 {name=R26
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1551.25 0 0 {name=R27
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1651.25 0 0 {name=R28
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1751.25 0 0 {name=R29
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1851.25 0 0 {name=R30
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -1951.25 0 0 {name=R31
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -2051.25 0 0 {name=R32
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -2151.25 0 0 {name=R33
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -2251.25 0 0 {name=R34
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 373.75 -2351.25 0 0 {name=R35
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -751.25 0 0 {name=R1
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -851.25 0 0 {name=R2
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -951.25 0 0 {name=R3
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1051.25 0 0 {name=R4
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1151.25 0 0 {name=R5
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1251.25 0 0 {name=R6
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1351.25 0 0 {name=R7
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1451.25 0 0 {name=R8
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1551.25 0 0 {name=R9
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1651.25 0 0 {name=R10
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1751.25 0 0 {name=R11
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1851.25 0 0 {name=R12
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1951.25 0 0 {name=R13
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2051.25 0 0 {name=R14
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2151.25 0 0 {name=R15
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2251.25 0 0 {name=R16
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2351.25 0 0 {name=R18
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {devices/lab_pin.sym} 773.75 -861.25 2 1 {name=p2 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -841.25 2 1 {name=p3 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -881.25 2 1 {name=p4 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -961.25 2 1 {name=p5 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -941.25 2 1 {name=p6 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -981.25 2 1 {name=p7 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1061.25 2 1 {name=p8 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1041.25 2 1 {name=p9 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1081.25 2 1 {name=p10 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1161.25 2 1 {name=p11 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1141.25 2 1 {name=p12 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1181.25 2 1 {name=p13 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1261.25 2 1 {name=p14 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1241.25 2 1 {name=p15 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1281.25 2 1 {name=p16 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1361.25 2 1 {name=p17 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1341.25 2 1 {name=p18 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1381.25 2 1 {name=p19 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1461.25 2 1 {name=p20 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1441.25 2 1 {name=p21 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1481.25 2 1 {name=p22 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1561.25 2 1 {name=p23 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1541.25 2 1 {name=p24 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1581.25 2 1 {name=p25 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1661.25 2 1 {name=p26 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1641.25 2 1 {name=p27 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1681.25 2 1 {name=p28 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1761.25 2 1 {name=p29 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1741.25 2 1 {name=p30 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1781.25 2 1 {name=p31 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1861.25 2 1 {name=p32 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1841.25 2 1 {name=p33 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1881.25 2 1 {name=p34 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -1961.25 2 1 {name=p35 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -1941.25 2 1 {name=p36 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -1981.25 2 1 {name=p37 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -2061.25 2 1 {name=p38 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -2041.25 2 1 {name=p39 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -2081.25 2 1 {name=p42 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -2161.25 2 1 {name=p43 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -2141.25 2 1 {name=p44 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -2181.25 2 1 {name=p45 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 773.75 -2261.25 2 1 {name=p46 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 773.75 -2241.25 2 1 {name=p47 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 773.75 -2281.25 2 1 {name=p48 sig_type=std_logic lab=VIN}
C {devices/vsource.sym} 373.75 -351.25 0 0 {name=V7 value="PWL(0ns 0.5 230ns 1.7)" savecurrent=false}
C {devices/gnd.sym} 373.75 -281.25 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} 373.75 -521.25 2 0 {name=p133 sig_type=std_logic lab=VIN}
C {devices/res.sym} 373.75 -451.25 0 0 {name=R36
value=1k
footprint=1206
device=resistor
m=1}
C {devices/code.sym} 1253.75 -441.25 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/lab_pin.sym} 1603.75 -1281.25 2 0 {name=p134 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1221.25 0 0 {name=l20 lab=GND}
C {devices/gnd.sym} 1603.75 -1121.25 0 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1181.25 2 0 {name=p137 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1021.25 0 0 {name=l22 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1081.25 2 0 {name=p138 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -921.25 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} 1603.75 -981.25 2 0 {name=p139 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -821.25 0 0 {name=l24 lab=GND}
C {devices/lab_pin.sym} 1603.75 -881.25 2 0 {name=p140 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -721.25 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} 1603.75 -781.25 2 0 {name=p141 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1321.25 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1381.25 2 0 {name=p142 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1421.25 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1481.25 2 0 {name=p143 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1521.25 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1581.25 2 0 {name=p144 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1621.25 0 0 {name=l29 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1681.25 2 0 {name=p145 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1721.25 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1781.25 2 0 {name=p146 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1821.25 0 0 {name=l31 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1881.25 2 0 {name=p147 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -1921.25 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} 1603.75 -1981.25 2 0 {name=p148 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -2021.25 0 0 {name=l33 lab=GND}
C {devices/lab_pin.sym} 1603.75 -2081.25 2 0 {name=p149 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -2121.25 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} 1603.75 -2181.25 2 0 {name=p150 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1603.75 -2221.25 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} 1603.75 -2281.25 2 0 {name=p151 sig_type=std_logic lab=VDD}
C {devices/noconn.sym} 1603.75 -741.25 2 0 {name=l57}
C {devices/noconn.sym} 1603.75 -841.25 2 0 {name=l58}
C {devices/noconn.sym} 1603.75 -941.25 2 0 {name=l59}
C {devices/noconn.sym} 1603.75 -1041.25 2 0 {name=l60}
C {devices/noconn.sym} 1603.75 -1141.25 2 0 {name=l61}
C {devices/noconn.sym} 1603.75 -1241.25 2 0 {name=l62}
C {devices/noconn.sym} 1603.75 -1341.25 2 0 {name=l63}
C {devices/noconn.sym} 1603.75 -1441.25 2 0 {name=l64}
C {devices/noconn.sym} 1603.75 -1541.25 2 0 {name=l65}
C {devices/noconn.sym} 1603.75 -1641.25 2 0 {name=l66}
C {devices/noconn.sym} 1603.75 -1741.25 2 0 {name=l67}
C {devices/noconn.sym} 1603.75 -1841.25 2 0 {name=l68}
C {devices/noconn.sym} 1603.75 -1941.25 2 0 {name=l69}
C {devices/noconn.sym} 1603.75 -2041.25 2 0 {name=l70}
C {devices/noconn.sym} 1603.75 -2141.25 2 0 {name=l71}
C {devices/noconn.sym} 1603.75 -2241.25 2 0 {name=l72}
C {devices/lab_pin.sym} 2442.5 -1872.5 2 0 {name=p158 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} 2442.5 -1852.5 2 0 {name=p159 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} 2442.5 -1832.5 2 0 {name=p160 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} 2442.5 -1892.5 2 0 {name=p162 sig_type=std_logic lab=OUT3}
C {devices/vdd.sym} 593.75 -121.25 0 0 {name=l80 lab=VDD}
C {devices/lab_pin.sym} 463.75 -42.5 1 0 {name=p164 sig_type=std_logic lab=GND}
C {devices/gnd.sym} 463.75 -12.5 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 1677.5 -2261.25 2 0 {name=p135 sig_type=std_logic lab=Q16}
C {devices/lab_pin.sym} 1677.5 -2161.25 2 0 {name=p136 sig_type=std_logic lab=Q15}
C {devices/lab_pin.sym} 1677.5 -2061.25 2 0 {name=p152 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 1677.5 -1961.25 2 0 {name=p153 sig_type=std_logic lab=Q13}
C {devices/lab_pin.sym} 1677.5 -1861.25 2 0 {name=p154 sig_type=std_logic lab=Q12}
C {devices/lab_pin.sym} 1677.5 -1761.25 2 0 {name=p155 sig_type=std_logic lab=Q11}
C {devices/lab_pin.sym} 1677.5 -1661.25 2 0 {name=p156 sig_type=std_logic lab=Q10}
C {devices/lab_pin.sym} 1677.5 -1561.25 2 0 {name=p157 sig_type=std_logic lab=Q9}
C {devices/lab_pin.sym} 1677.5 -1461.25 2 0 {name=p163 sig_type=std_logic lab=Q8}
C {devices/lab_pin.sym} 1677.5 -1361.25 2 0 {name=p165 sig_type=std_logic lab=Q7}
C {devices/lab_pin.sym} 1677.5 -1261.25 2 0 {name=p166 sig_type=std_logic lab=Q6}
C {devices/lab_pin.sym} 1677.5 -1161.25 2 0 {name=p167 sig_type=std_logic lab=Q5}
C {devices/lab_pin.sym} 1677.5 -1061.25 2 0 {name=p168 sig_type=std_logic lab=Q4}
C {devices/lab_pin.sym} 1677.5 -961.25 2 0 {name=p169 sig_type=std_logic lab=Q3}
C {devices/lab_pin.sym} 1677.5 -861.25 2 0 {name=p170 sig_type=std_logic lab=Q2}
C {devices/lab_pin.sym} 1677.5 -761.25 2 0 {name=p171 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 2142.5 -1852.5 0 0 {name=p172 sig_type=std_logic lab=VDD}
C {sky130_stdcells/buf_1.sym} 1263.75 -2281.25 0 0 {name=x64 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2261.25 0 0 {name=x34 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2181.25 0 0 {name=x35 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2161.25 0 0 {name=x36 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2081.25 0 0 {name=x37 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2061.25 0 0 {name=x38 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1981.25 0 0 {name=x39 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1961.25 0 0 {name=x40 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1881.25 0 0 {name=x41 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1861.25 0 0 {name=x42 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1781.25 0 0 {name=x43 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1761.25 0 0 {name=x44 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1681.25 0 0 {name=x45 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1661.25 0 0 {name=x46 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1581.25 0 0 {name=x47 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1561.25 0 0 {name=x48 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1481.25 0 0 {name=x49 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1461.25 0 0 {name=x50 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1381.25 0 0 {name=x51 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1361.25 0 0 {name=x52 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1281.25 0 0 {name=x53 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1261.25 0 0 {name=x54 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1181.25 0 0 {name=x55 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1161.25 0 0 {name=x56 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1081.25 0 0 {name=x57 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1061.25 0 0 {name=x58 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -981.25 0 0 {name=x59 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -961.25 0 0 {name=x60 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -881.25 0 0 {name=x61 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -861.25 0 0 {name=x62 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -781.25 0 0 {name=x63 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -761.25 0 0 {name=x65 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -2171.25 0 0 {name=x3}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -2271.25 0 0 {name=x4}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1971.25 0 0 {name=x5}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -2071.25 0 0 {name=x6}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1771.25 0 0 {name=x7}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1871.25 0 0 {name=x8}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1571.25 0 0 {name=x9}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1671.25 0 0 {name=x10}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1371.25 0 0 {name=x11}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1471.25 0 0 {name=x12}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1171.25 0 0 {name=x13}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1271.25 0 0 {name=x14}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -971.25 0 0 {name=x15}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -1071.25 0 0 {name=x16}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -771.25 0 0 {name=x17}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v3_sym.sym} 963.75 -871.25 0 0 {name=x18}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -2251.25 0 0 {name=x19}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -2151.25 0 0 {name=x20}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -2051.25 0 0 {name=x21}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1951.25 0 0 {name=x22}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1851.25 0 0 {name=x23}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1751.25 0 0 {name=x24}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1651.25 0 0 {name=x25}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1551.25 0 0 {name=x26}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1451.25 0 0 {name=x27}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1351.25 0 0 {name=x28}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1251.25 0 0 {name=x29}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1151.25 0 0 {name=x30}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1051.25 0 0 {name=x31}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -951.25 0 0 {name=x32}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -851.25 0 0 {name=x33}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -751.25 0 0 {name=x66}
C {/foss/designs/Analog_FA23_SP24/PriorityEncoder/xschem/16to4_PriorityEncoder_v0p0p1.sym} 2292.5 -1712.5 0 0 {name=x1}
C {devices/lab_pin.sym} 2142.5 -1892.5 0 0 {name=p161 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 2142.5 -1872.5 1 0 {name=l40 lab=GND}
