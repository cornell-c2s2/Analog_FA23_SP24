v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1113.75 -1960 1143.75 -1960 {
lab=VDD}
N 940 -1983.75 940 -1943.75 {
lab=VIN}
N 1383.75 -2821.25 1383.75 -2801.25 {
lab=#net1}
N 1383.75 -2721.25 1383.75 -2701.25 {
lab=#net2}
N 1383.75 -2621.25 1383.75 -2601.25 {
lab=VL}
N 1383.75 -2921.25 1383.75 -2901.25 {
lab=#net3}
N 1383.75 -3021.25 1383.75 -3001.25 {
lab=#net4}
N 1383.75 -3121.25 1383.75 -3101.25 {
lab=#net5}
N 1383.75 -3221.25 1383.75 -3201.25 {
lab=#net6}
N 1383.75 -3321.25 1383.75 -3301.25 {
lab=#net7}
N 1383.75 -3421.25 1383.75 -3401.25 {
lab=#net8}
N 1383.75 -3521.25 1383.75 -3501.25 {
lab=#net9}
N 1383.75 -3621.25 1383.75 -3601.25 {
lab=#net10}
N 1383.75 -3721.25 1383.75 -3701.25 {
lab=#net11}
N 1383.75 -3821.25 1383.75 -3801.25 {
lab=#net12}
N 1383.75 -3921.25 1383.75 -3901.25 {
lab=#net13}
N 1383.75 -4021.25 1383.75 -4001.25 {
lab=#net14}
N 1383.75 -4121.25 1383.75 -4101.25 {
lab=#net15}
N 1383.75 -4221.25 1383.75 -4201.25 {
lab=#net16}
N 1323.75 -4171.25 1363.75 -4171.25 {
lab=GND}
N 1323.75 -4171.25 1323.75 -4071.25 {
lab=GND}
N 1323.75 -4071.25 1363.75 -4071.25 {
lab=GND}
N 1323.75 -3971.25 1363.75 -3971.25 {
lab=GND}
N 1323.75 -3871.25 1363.75 -3871.25 {
lab=GND}
N 1323.75 -3771.25 1363.75 -3771.25 {
lab=GND}
N 1323.75 -3671.25 1363.75 -3671.25 {
lab=GND}
N 1323.75 -3571.25 1363.75 -3571.25 {
lab=GND}
N 1323.75 -3471.25 1363.75 -3471.25 {
lab=GND}
N 1323.75 -3371.25 1363.75 -3371.25 {
lab=GND}
N 1323.75 -3271.25 1363.75 -3271.25 {
lab=GND}
N 1323.75 -3171.25 1363.75 -3171.25 {
lab=GND}
N 1323.75 -3071.25 1363.75 -3071.25 {
lab=GND}
N 1323.75 -2971.25 1363.75 -2971.25 {
lab=GND}
N 1323.75 -2871.25 1363.75 -2871.25 {
lab=GND}
N 1323.75 -2771.25 1363.75 -2771.25 {
lab=GND}
N 1323.75 -2671.25 1363.75 -2671.25 {
lab=GND}
N 1323.75 -2671.25 1323.75 -2621.25 {
lab=GND}
N 1323.75 -2871.25 1323.75 -2771.25 {
lab=GND}
N 1323.75 -2971.25 1323.75 -2871.25 {
lab=GND}
N 1383.75 -2721.25 1603.75 -2721.25 {
lab=#net2}
N 1323.75 -4271.25 1363.75 -4271.25 {
lab=GND}
N 1323.75 -4271.25 1323.75 -4171.25 {
lab=GND}
N 1383.75 -2821.25 1620 -2821.25 {
lab=#net1}
N 1383.75 -2921.25 1631.25 -2921.25 {
lab=#net3}
N 1383.75 -3021.25 1642.5 -3021.25 {
lab=#net4}
N 1383.75 -3121.25 1651.25 -3121.25 {
lab=#net5}
N 1383.75 -3221.25 1661.25 -3221.25 {
lab=#net6}
N 1383.75 -3321.25 1646.25 -3321.25 {
lab=#net7}
N 1383.75 -3421.25 1603.75 -3421.25 {
lab=#net8}
N 1383.75 -3521.25 1722.5 -3521.25 {
lab=#net9}
N 1383.75 -3621.25 1603.75 -3621.25 {
lab=#net10}
N 1383.75 -3721.25 1603.75 -3721.25 {
lab=#net11}
N 1383.75 -3821.25 1607.5 -3821.25 {
lab=#net12}
N 1383.75 -3921.25 1628.75 -3921.25 {
lab=#net13}
N 1383.75 -4021.25 1625 -4021.25 {
lab=#net14}
N 1383.75 -4121.25 1611.25 -4121.25 {
lab=#net15}
N 1383.75 -4221.25 1603.75 -4221.25 {
lab=#net16}
N 1323.75 -4071.25 1323.75 -3971.25 {
lab=GND}
N 1323.75 -3971.25 1323.75 -3871.25 {
lab=GND}
N 1323.75 -3871.25 1323.75 -3771.25 {
lab=GND}
N 1323.75 -3771.25 1323.75 -3671.25 {
lab=GND}
N 1323.75 -3671.25 1323.75 -3571.25 {
lab=GND}
N 1323.75 -3571.25 1323.75 -3471.25 {
lab=GND}
N 1323.75 -3471.25 1323.75 -3371.25 {
lab=GND}
N 1323.75 -3371.25 1323.75 -3271.25 {
lab=GND}
N 1323.75 -3271.25 1323.75 -3171.25 {
lab=GND}
N 1323.75 -3171.25 1323.75 -3071.25 {
lab=GND}
N 1323.75 -3071.25 1323.75 -2971.25 {
lab=GND}
N 1323.75 -2771.25 1323.75 -2671.25 {
lab=GND}
N 1383.75 -2641.25 1383.75 -2621.25 {
lab=VL}
N 1383.75 -2741.25 1383.75 -2721.25 {
lab=#net2}
N 1383.75 -2841.25 1383.75 -2821.25 {
lab=#net1}
N 1383.75 -2941.25 1383.75 -2921.25 {
lab=#net3}
N 1383.75 -3041.25 1383.75 -3021.25 {
lab=#net4}
N 1383.75 -3141.25 1383.75 -3121.25 {
lab=#net5}
N 1383.75 -3241.25 1383.75 -3221.25 {
lab=#net6}
N 1383.75 -3341.25 1383.75 -3321.25 {
lab=#net7}
N 1383.75 -3441.25 1383.75 -3421.25 {
lab=#net8}
N 1383.75 -3541.25 1383.75 -3521.25 {
lab=#net9}
N 1383.75 -3641.25 1383.75 -3621.25 {
lab=#net10}
N 1383.75 -3741.25 1383.75 -3721.25 {
lab=#net11}
N 1383.75 -3841.25 1383.75 -3821.25 {
lab=#net12}
N 1383.75 -3941.25 1383.75 -3921.25 {
lab=#net13}
N 1383.75 -4041.25 1383.75 -4021.25 {
lab=#net14}
N 1383.75 -4141.25 1383.75 -4121.25 {
lab=#net15}
N 1383.75 -4241.25 1383.75 -4221.25 {
lab=#net16}
N 1603.75 -4425 1737.5 -4425 {
lab=#net16}
N 1603.75 -4425 1603.75 -4221.25 {
lab=#net16}
N 1611.25 -4295 1611.25 -4121.25 {
lab=#net15}
N 1611.25 -4295 1737.5 -4295 {
lab=#net15}
N 1625 -4165 1625 -4021.25 {
lab=#net14}
N 1625 -4165 1738.75 -4165 {
lab=#net14}
N 1628.75 -4035 1628.75 -3921.25 {
lab=#net13}
N 1628.75 -4035 1737.5 -4035 {
lab=#net13}
N 1607.5 -3905 1737.5 -3905 {
lab=#net12}
N 1607.5 -3905 1607.5 -3821.25 {
lab=#net12}
N 1603.75 -3775 1737.5 -3775 {
lab=#net11}
N 1603.75 -3775 1603.75 -3721.25 {
lab=#net11}
N 1603.75 -3645 1737.5 -3645 {
lab=#net10}
N 1603.75 -3645 1603.75 -3621.25 {
lab=#net10}
N 1722.5 -3521.25 1722.5 -3515 {
lab=#net9}
N 1722.5 -3515 1737.5 -3515 {
lab=#net9}
N 1603.75 -3421.25 1603.75 -3385 {
lab=#net8}
N 1603.75 -3385 1737.5 -3385 {
lab=#net8}
N 1646.25 -3321.25 1646.25 -3255 {
lab=#net7}
N 1646.25 -3255 1737.5 -3255 {
lab=#net7}
N 1661.25 -3221.25 1661.25 -3125 {
lab=#net6}
N 1661.25 -3125 1737.5 -3125 {
lab=#net6}
N 1651.25 -3121.25 1651.25 -2995 {
lab=#net5}
N 1651.25 -2995 1737.5 -2995 {
lab=#net5}
N 1642.5 -3021.25 1642.5 -2865 {
lab=#net4}
N 1642.5 -2865 1737.5 -2865 {
lab=#net4}
N 1631.25 -2921.25 1631.25 -2735 {
lab=#net3}
N 1631.25 -2735 1737.5 -2735 {
lab=#net3}
N 1620 -2821.25 1620 -2605 {
lab=#net1}
N 1620 -2605 1737.5 -2605 {
lab=#net1}
N 1603.75 -2721.25 1603.75 -2475 {
lab=#net2}
N 1603.75 -2475 1738.75 -2475 {
lab=#net2}
N 2035 -4465 2290 -4465 {
lab=#net17}
N 2290 -4465 2290 -3587.5 {
lab=#net17}
N 2290 -3587.5 2440 -3587.5 {
lab=#net17}
N 2037.5 -4335 2277.5 -4335 {
lab=#net18}
N 2277.5 -4335 2277.5 -3567.5 {
lab=#net18}
N 2277.5 -3567.5 2440 -3567.5 {
lab=#net18}
N 2037.5 -4205 2265 -4205 {
lab=#net19}
N 2265 -4205 2265 -3547.5 {
lab=#net19}
N 2265 -3547.5 2440 -3547.5 {
lab=#net19}
N 2037.5 -4075 2247.5 -4075 {
lab=#net20}
N 2247.5 -4075 2247.5 -3527.5 {
lab=#net20}
N 2247.5 -3527.5 2440 -3527.5 {
lab=#net20}
N 2037.5 -3945 2237.5 -3945 {
lab=#net21}
N 2237.5 -3945 2237.5 -3507.5 {
lab=#net21}
N 2237.5 -3507.5 2440 -3507.5 {
lab=#net21}
N 2037.5 -3815 2222.5 -3815 {
lab=#net22}
N 2222.5 -3815 2222.5 -3487.5 {
lab=#net22}
N 2222.5 -3487.5 2440 -3487.5 {
lab=#net22}
N 2037.5 -3685 2215 -3685 {
lab=#net23}
N 2215 -3685 2215 -3467.5 {
lab=#net23}
N 2215 -3467.5 2440 -3467.5 {
lab=#net23}
N 2037.5 -3555 2200 -3555 {
lab=#net24}
N 2200 -3555 2200 -3447.5 {
lab=#net24}
N 2200 -3447.5 2440 -3447.5 {
lab=#net24}
N 2037.5 -3425 2422.5 -3425 {
lab=#net25}
N 2422.5 -3427.5 2422.5 -3425 {
lab=#net25}
N 2422.5 -3427.5 2440 -3427.5 {
lab=#net25}
N 2037.5 -3295 2067.5 -3295 {
lab=#net26}
N 2067.5 -3407.5 2067.5 -3295 {
lab=#net26}
N 2067.5 -3407.5 2440 -3407.5 {
lab=#net26}
N 2037.5 -3165 2085 -3165 {
lab=#net27}
N 2085 -3387.5 2085 -3165 {
lab=#net27}
N 2085 -3387.5 2440 -3387.5 {
lab=#net27}
N 2037.5 -3035 2120 -3035 {
lab=#net28}
N 2120 -3367.5 2120 -3035 {
lab=#net28}
N 2120 -3367.5 2440 -3367.5 {
lab=#net28}
N 2037.5 -2905 2152.5 -2905 {
lab=#net29}
N 2152.5 -3347.5 2152.5 -2905 {
lab=#net29}
N 2152.5 -3347.5 2440 -3347.5 {
lab=#net29}
N 2037.5 -2775 2197.5 -2775 {
lab=#net30}
N 2197.5 -3327.5 2197.5 -2775 {
lab=#net30}
N 2197.5 -3327.5 2440 -3327.5 {
lab=#net30}
N 2037.5 -2645 2222.5 -2645 {
lab=#net31}
N 2222.5 -3307.5 2222.5 -2645 {
lab=#net31}
N 2222.5 -3307.5 2440 -3307.5 {
lab=#net31}
N 2037.5 -2515 2262.5 -2515 {
lab=#net32}
N 2262.5 -3287.5 2262.5 -2515 {
lab=#net32}
N 2262.5 -3287.5 2440 -3287.5 {
lab=#net32}
N 1185 -1952.5 1215 -1952.5 {
lab=CLK}
N 1040 -1985 1040 -1942.5 {
lab=GND}
C {devices/lab_pin.sym} 1143.75 -1960 1 0 {name=p198 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 940 -1983.75 1 0 {name=p133 sig_type=std_logic lab=VIN}
C {devices/code.sym} 956.25 -2526.25 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/vdd.sym} 1113.75 -1960 0 0 {name=l80 lab=VDD}
C {devices/lab_pin.sym} 1040 -1985 1 0 {name=p164 sig_type=std_logic lab=GND}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -2671.25 0 0 {name=R1
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -2771.25 0 0 {name=R2
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -2871.25 0 0 {name=R3
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -2971.25 0 0 {name=R4
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3071.25 0 0 {name=R5
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3171.25 0 0 {name=R6
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3271.25 0 0 {name=R7
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3371.25 0 0 {name=R8
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3471.25 0 0 {name=R9
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3571.25 0 0 {name=R10
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3671.25 0 0 {name=R11
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3771.25 0 0 {name=R12
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3871.25 0 0 {name=R13
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3971.25 0 0 {name=R14
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -4071.25 0 0 {name=R15
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -4171.25 0 0 {name=R16
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -4271.25 0 0 {name=R18
L=2.667
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {/foss/designs/Analog_FA23_SP24/PriorityEncoder/xschem/16to4_PriorityEncoder_v0p0p1.sym} 2590 -3467.5 0 0 {name=x1}
C {devices/gnd.sym} 2440 -3627.5 1 0 {name=l40 lab=GND}
C {devices/opin.sym} 2740 -3647.5 0 0 {name=p173 lab=OUT3}
C {devices/opin.sym} 2740 -3627.5 0 0 {name=p158 lab=OUT2}
C {devices/opin.sym} 2740 -3607.5 0 0 {name=p159 lab=OUT1}
C {devices/opin.sym} 2740 -3587.5 0 0 {name=p160 lab=OUT0}
C {devices/ipin.sym} 1383.75 -4301.25 1 0 {name=p1 lab=VFS}
C {/foss/designs/Analog_FA23_SP24/PTAT/xschem/PTAT_v0p0p0.sym} 1423.75 -4462.5 0 0 {name=x18}
C {devices/gnd.sym} 1273.75 -4452.5 1 0 {name=l138 lab=GND}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -4285 0 0 {name=x2}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -4155 0 0 {name=x3}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -4025 0 0 {name=x4}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3895 0 0 {name=x5}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3765 0 0 {name=x6}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3635 0 0 {name=x7}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3505 0 0 {name=x8}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3375 0 0 {name=x9}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3245 0 0 {name=x10}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3115 0 0 {name=x11}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2985 0 0 {name=x12}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2855 0 0 {name=x13}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2725 0 0 {name=x14}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2595 0 0 {name=x15}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2465 0 0 {name=x16}
C {devices/gnd.sym} 1737.5 -4445 1 0 {name=l4 lab=GND}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -4415 0 0 {name=x17}
C {devices/lab_pin.sym} 1273.75 -4472.5 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1573.75 -4472.5 2 0 {name=p5 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -4365 0 0 {name=p6 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -4385 0 0 {name=p7 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -4405 0 0 {name=p8 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -4465 0 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -4315 1 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 1737.5 -4235 0 0 {name=p10 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -4255 0 0 {name=p11 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -4275 0 0 {name=p12 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -4335 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -4185 1 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 1737.5 -4105 0 0 {name=p14 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -4125 0 0 {name=p15 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -4145 0 0 {name=p16 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -4205 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -4055 1 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 1737.5 -3975 0 0 {name=p18 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -3995 0 0 {name=p19 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -4015 0 0 {name=p20 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -4075 0 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -3925 1 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} 1737.5 -3845 0 0 {name=p22 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -3865 0 0 {name=p23 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -3885 0 0 {name=p24 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -3945 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -3795 1 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 1737.5 -3715 0 0 {name=p26 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -3735 0 0 {name=p27 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -3755 0 0 {name=p28 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -3815 0 0 {name=p29 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -3665 1 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 1737.5 -3585 0 0 {name=p30 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -3605 0 0 {name=p31 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -3625 0 0 {name=p32 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -3685 0 0 {name=p33 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -3535 1 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 1737.5 -3455 0 0 {name=p34 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -3475 0 0 {name=p35 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -3495 0 0 {name=p36 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -3555 0 0 {name=p37 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -3405 1 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 1737.5 -3325 0 0 {name=p38 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -3345 0 0 {name=p39 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -3365 0 0 {name=p40 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -3425 0 0 {name=p41 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -3275 1 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 1737.5 -3195 0 0 {name=p42 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -3215 0 0 {name=p43 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -3235 0 0 {name=p44 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -3295 0 0 {name=p45 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -3145 1 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} 1737.5 -3065 0 0 {name=p46 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -3085 0 0 {name=p47 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -3105 0 0 {name=p48 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -3165 0 0 {name=p49 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -3015 1 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 1737.5 -2935 0 0 {name=p50 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -2955 0 0 {name=p51 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -2975 0 0 {name=p52 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -3035 0 0 {name=p53 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -2885 1 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 1737.5 -2805 0 0 {name=p54 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -2825 0 0 {name=p55 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -2845 0 0 {name=p56 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -2905 0 0 {name=p57 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -2755 1 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} 1737.5 -2675 0 0 {name=p58 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -2695 0 0 {name=p59 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -2715 0 0 {name=p60 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -2775 0 0 {name=p61 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -2625 1 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 1737.5 -2545 0 0 {name=p62 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -2565 0 0 {name=p63 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -2585 0 0 {name=p64 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -2645 0 0 {name=p65 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1737.5 -2495 1 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} 1737.5 -2415 0 0 {name=p66 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1737.5 -2435 0 0 {name=p67 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1737.5 -2455 0 0 {name=p68 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1737.5 -2515 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2440 -3647.5 0 0 {name=p70 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2440 -3607.5 0 0 {name=p71 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 1383.75 -2601.25 3 0 {name=p3 lab=VL}
C {devices/ipin.sym} 1113.75 -1960 3 0 {name=p72 lab=VDD}
C {devices/ipin.sym} 1040 -1942.5 3 0 {name=p73 lab=GND}
C {devices/lab_pin.sym} 1215 -1952.5 2 0 {name=p2 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 1185 -1952.5 3 0 {name=p74 lab=CLK}
C {devices/ipin.sym} 940 -1945 3 0 {name=p75 lab=VIN}
C {devices/lab_pin.sym} 1323.75 -2621.25 3 0 {name=p76 sig_type=std_logic lab=GND}
C {devices/gnd.sym} 1040 -1962.5 1 0 {name=l2 lab=GND}
