v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 593.75 -901.25 593.75 -881.25 {
lab=#net1}
N 593.75 -801.25 593.75 -781.25 {
lab=#net2}
N 593.75 -701.25 593.75 -681.25 {
lab=VL}
N 593.75 -1001.25 593.75 -981.25 {
lab=#net3}
N 593.75 -1101.25 593.75 -1081.25 {
lab=#net4}
N 593.75 -1201.25 593.75 -1181.25 {
lab=#net5}
N 593.75 -1301.25 593.75 -1281.25 {
lab=#net6}
N 593.75 -1401.25 593.75 -1381.25 {
lab=#net7}
N 593.75 -1501.25 593.75 -1481.25 {
lab=#net8}
N 593.75 -1601.25 593.75 -1581.25 {
lab=#net9}
N 593.75 -1701.25 593.75 -1681.25 {
lab=#net10}
N 593.75 -1801.25 593.75 -1781.25 {
lab=#net11}
N 593.75 -1901.25 593.75 -1881.25 {
lab=#net12}
N 593.75 -2001.25 593.75 -1981.25 {
lab=#net13}
N 593.75 -2101.25 593.75 -2081.25 {
lab=#net14}
N 593.75 -2201.25 593.75 -2181.25 {
lab=#net15}
N 593.75 -2301.25 593.75 -2281.25 {
lab=#net16}
N 533.75 -2251.25 573.75 -2251.25 {
lab=VL}
N 533.75 -2251.25 533.75 -2151.25 {
lab=VL}
N 533.75 -2151.25 573.75 -2151.25 {
lab=VL}
N 533.75 -2051.25 573.75 -2051.25 {
lab=VL}
N 533.75 -1951.25 573.75 -1951.25 {
lab=VL}
N 533.75 -1851.25 573.75 -1851.25 {
lab=VL}
N 533.75 -1751.25 573.75 -1751.25 {
lab=VL}
N 533.75 -1651.25 573.75 -1651.25 {
lab=VL}
N 533.75 -1551.25 573.75 -1551.25 {
lab=VL}
N 533.75 -1451.25 573.75 -1451.25 {
lab=VL}
N 533.75 -1351.25 573.75 -1351.25 {
lab=VL}
N 533.75 -1251.25 573.75 -1251.25 {
lab=VL}
N 533.75 -1151.25 573.75 -1151.25 {
lab=VL}
N 533.75 -1051.25 573.75 -1051.25 {
lab=VL}
N 533.75 -951.25 573.75 -951.25 {
lab=VL}
N 533.75 -851.25 573.75 -851.25 {
lab=VL}
N 533.75 -751.25 573.75 -751.25 {
lab=VL}
N 533.75 -701.25 593.75 -701.25 {
lab=VL}
N 533.75 -751.25 533.75 -701.25 {
lab=VL}
N 533.75 -951.25 533.75 -851.25 {
lab=VL}
N 533.75 -1051.25 533.75 -951.25 {
lab=VL}
N 593.75 -801.25 813.75 -801.25 {
lab=#net2}
N 593.75 -2421.25 593.75 -2381.25 {
lab=VFS}
N 533.75 -2351.25 573.75 -2351.25 {
lab=VL}
N 533.75 -2351.25 533.75 -2251.25 {
lab=VL}
N 593.75 -901.25 813.75 -901.25 {
lab=#net1}
N 593.75 -1001.25 813.75 -1001.25 {
lab=#net3}
N 593.75 -1101.25 813.75 -1101.25 {
lab=#net4}
N 593.75 -1201.25 813.75 -1201.25 {
lab=#net5}
N 593.75 -1301.25 813.75 -1301.25 {
lab=#net6}
N 593.75 -1401.25 813.75 -1401.25 {
lab=#net7}
N 593.75 -1501.25 813.75 -1501.25 {
lab=#net8}
N 593.75 -1601.25 813.75 -1601.25 {
lab=#net9}
N 593.75 -1701.25 813.75 -1701.25 {
lab=#net10}
N 593.75 -1801.25 813.75 -1801.25 {
lab=#net11}
N 593.75 -1901.25 813.75 -1901.25 {
lab=#net12}
N 593.75 -2001.25 813.75 -2001.25 {
lab=#net13}
N 593.75 -2101.25 813.75 -2101.25 {
lab=#net14}
N 593.75 -2201.25 813.75 -2201.25 {
lab=#net15}
N 593.75 -2301.25 813.75 -2301.25 {
lab=#net16}
N 533.75 -2151.25 533.75 -2051.25 {
lab=VL}
N 533.75 -2051.25 533.75 -1951.25 {
lab=VL}
N 533.75 -1951.25 533.75 -1851.25 {
lab=VL}
N 533.75 -1851.25 533.75 -1751.25 {
lab=VL}
N 533.75 -1751.25 533.75 -1651.25 {
lab=VL}
N 533.75 -1651.25 533.75 -1551.25 {
lab=VL}
N 533.75 -1551.25 533.75 -1451.25 {
lab=VL}
N 533.75 -1451.25 533.75 -1351.25 {
lab=VL}
N 533.75 -1351.25 533.75 -1251.25 {
lab=VL}
N 533.75 -1251.25 533.75 -1151.25 {
lab=VL}
N 533.75 -1151.25 533.75 -1051.25 {
lab=VL}
N 533.75 -851.25 533.75 -751.25 {
lab=VL}
N 593.75 -721.25 593.75 -701.25 {
lab=VL}
N 593.75 -821.25 593.75 -801.25 {
lab=#net2}
N 593.75 -921.25 593.75 -901.25 {
lab=#net1}
N 593.75 -1021.25 593.75 -1001.25 {
lab=#net3}
N 593.75 -1121.25 593.75 -1101.25 {
lab=#net4}
N 593.75 -1221.25 593.75 -1201.25 {
lab=#net5}
N 593.75 -1321.25 593.75 -1301.25 {
lab=#net6}
N 593.75 -1421.25 593.75 -1401.25 {
lab=#net7}
N 593.75 -1521.25 593.75 -1501.25 {
lab=#net8}
N 593.75 -1621.25 593.75 -1601.25 {
lab=#net9}
N 593.75 -1721.25 593.75 -1701.25 {
lab=#net10}
N 593.75 -1821.25 593.75 -1801.25 {
lab=#net11}
N 593.75 -1921.25 593.75 -1901.25 {
lab=#net12}
N 593.75 -2021.25 593.75 -2001.25 {
lab=#net13}
N 593.75 -2121.25 593.75 -2101.25 {
lab=#net14}
N 593.75 -2221.25 593.75 -2201.25 {
lab=#net15}
N 593.75 -2321.25 593.75 -2301.25 {
lab=#net16}
N 813.75 -2487.5 813.75 -2301.25 {
lab=#net16}
N 885 -2505 947.5 -2505 {
lab=#net16}
N 813.75 -2505 885 -2505 {
lab=#net16}
N 813.75 -2505 813.75 -2487.5 {
lab=#net16}
N 813.75 -2201.25 821.25 -2201.25 {
lab=#net15}
N 821.25 -2375 821.25 -2201.25 {
lab=#net15}
N 821.25 -2375 947.5 -2375 {
lab=#net15}
N 813.75 -2101.25 835 -2101.25 {
lab=#net14}
N 835 -2245 835 -2101.25 {
lab=#net14}
N 835 -2245 948.75 -2245 {
lab=#net14}
N 813.75 -2001.25 838.75 -2001.25 {
lab=#net13}
N 838.75 -2115 838.75 -2001.25 {
lab=#net13}
N 838.75 -2115 947.5 -2115 {
lab=#net13}
N 817.5 -1985 947.5 -1985 {
lab=#net12}
N 817.5 -1985 817.5 -1901.25 {
lab=#net12}
N 813.75 -1901.25 817.5 -1901.25 {
lab=#net12}
N 813.75 -1855 947.5 -1855 {
lab=#net11}
N 813.75 -1855 813.75 -1801.25 {
lab=#net11}
N 813.75 -1725 947.5 -1725 {
lab=#net10}
N 813.75 -1725 813.75 -1701.25 {
lab=#net10}
N 813.75 -1601.25 932.5 -1601.25 {
lab=#net9}
N 932.5 -1601.25 932.5 -1595 {
lab=#net9}
N 932.5 -1595 947.5 -1595 {
lab=#net9}
N 813.75 -1501.25 813.75 -1466.25 {
lab=#net8}
N 813.75 -1465 947.5 -1465 {
lab=#net8}
N 813.75 -1466.25 813.75 -1465 {
lab=#net8}
N 813.75 -1401.25 856.25 -1401.25 {
lab=#net7}
N 856.25 -1401.25 856.25 -1335 {
lab=#net7}
N 856.25 -1335 947.5 -1335 {
lab=#net7}
N 813.75 -1301.25 871.25 -1301.25 {
lab=#net6}
N 871.25 -1301.25 871.25 -1205 {
lab=#net6}
N 871.25 -1205 947.5 -1205 {
lab=#net6}
N 813.75 -1201.25 861.25 -1201.25 {
lab=#net5}
N 861.25 -1201.25 861.25 -1075 {
lab=#net5}
N 861.25 -1075 947.5 -1075 {
lab=#net5}
N 813.75 -1101.25 852.5 -1101.25 {
lab=#net4}
N 852.5 -1101.25 852.5 -948.75 {
lab=#net4}
N 852.5 -945 947.5 -945 {
lab=#net4}
N 852.5 -948.75 852.5 -945 {
lab=#net4}
N 813.75 -1001.25 841.25 -1001.25 {
lab=#net3}
N 841.25 -1001.25 841.25 -815 {
lab=#net3}
N 841.25 -815 947.5 -815 {
lab=#net3}
N 813.75 -901.25 830 -901.25 {
lab=#net1}
N 830 -901.25 830 -685 {
lab=#net1}
N 830 -685 947.5 -685 {
lab=#net1}
N 813.75 -801.25 813.75 -555 {
lab=#net2}
N 813.75 -555 948.75 -555 {
lab=#net2}
N 1245 -2545 1315 -2545 {
lab=#net17}
N 1315 -2545 1500 -2545 {
lab=#net17}
N 1500 -2545 1500 -1667.5 {
lab=#net17}
N 1500 -1667.5 1650 -1667.5 {
lab=#net17}
N 1247.5 -2415 1487.5 -2415 {
lab=#net18}
N 1487.5 -2415 1487.5 -1647.5 {
lab=#net18}
N 1487.5 -1647.5 1650 -1647.5 {
lab=#net18}
N 1247.5 -2285 1475 -2285 {
lab=#net19}
N 1475 -2285 1475 -1627.5 {
lab=#net19}
N 1475 -1627.5 1650 -1627.5 {
lab=#net19}
N 1247.5 -2155 1457.5 -2155 {
lab=#net20}
N 1457.5 -2155 1457.5 -1607.5 {
lab=#net20}
N 1457.5 -1607.5 1650 -1607.5 {
lab=#net20}
N 1247.5 -2025 1447.5 -2025 {
lab=#net21}
N 1447.5 -2025 1447.5 -1587.5 {
lab=#net21}
N 1447.5 -1587.5 1650 -1587.5 {
lab=#net21}
N 1247.5 -1895 1432.5 -1895 {
lab=#net22}
N 1432.5 -1895 1432.5 -1567.5 {
lab=#net22}
N 1432.5 -1567.5 1650 -1567.5 {
lab=#net22}
N 1247.5 -1765 1425 -1765 {
lab=#net23}
N 1425 -1765 1425 -1547.5 {
lab=#net23}
N 1425 -1547.5 1650 -1547.5 {
lab=#net23}
N 1247.5 -1635 1410 -1635 {
lab=#net24}
N 1410 -1635 1410 -1527.5 {
lab=#net24}
N 1410 -1527.5 1650 -1527.5 {
lab=#net24}
N 1247.5 -1505 1632.5 -1505 {
lab=#net25}
N 1632.5 -1507.5 1632.5 -1505 {
lab=#net25}
N 1632.5 -1507.5 1650 -1507.5 {
lab=#net25}
N 1247.5 -1375 1277.5 -1375 {
lab=#net26}
N 1277.5 -1487.5 1277.5 -1375 {
lab=#net26}
N 1277.5 -1487.5 1650 -1487.5 {
lab=#net26}
N 1247.5 -1245 1295 -1245 {
lab=#net27}
N 1295 -1467.5 1295 -1245 {
lab=#net27}
N 1295 -1467.5 1650 -1467.5 {
lab=#net27}
N 1247.5 -1115 1330 -1115 {
lab=#net28}
N 1330 -1447.5 1330 -1115 {
lab=#net28}
N 1330 -1447.5 1650 -1447.5 {
lab=#net28}
N 1247.5 -985 1362.5 -985 {
lab=#net29}
N 1362.5 -1427.5 1362.5 -985 {
lab=#net29}
N 1362.5 -1427.5 1650 -1427.5 {
lab=#net29}
N 1247.5 -855 1407.5 -855 {
lab=#net30}
N 1407.5 -1407.5 1407.5 -855 {
lab=#net30}
N 1407.5 -1407.5 1650 -1407.5 {
lab=#net30}
N 1247.5 -725 1432.5 -725 {
lab=#net31}
N 1432.5 -1387.5 1432.5 -725 {
lab=#net31}
N 1432.5 -1387.5 1650 -1387.5 {
lab=#net31}
N 1247.5 -595 1472.5 -595 {
lab=#net32}
N 1472.5 -1367.5 1472.5 -595 {
lab=#net32}
N 1472.5 -1367.5 1650 -1367.5 {
lab=#net32}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -751.25 0 0 {name=R1
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -851.25 0 0 {name=R2
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -951.25 0 0 {name=R3
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1051.25 0 0 {name=R4
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1151.25 0 0 {name=R5
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1251.25 0 0 {name=R6
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1351.25 0 0 {name=R7
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1451.25 0 0 {name=R8
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1551.25 0 0 {name=R9
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1651.25 0 0 {name=R10
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1751.25 0 0 {name=R11
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1851.25 0 0 {name=R12
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1951.25 0 0 {name=R13
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2051.25 0 0 {name=R14
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2151.25 0 0 {name=R15
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2251.25 0 0 {name=R16
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2351.25 0 0 {name=R18
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {devices/code.sym} 93.75 -1138.75 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {/foss/designs/Analog_FA23_SP24/PriorityEncoder/xschem/16to4_PriorityEncoder_v0p0p1.sym} 1800 -1547.5 0 0 {name=x1}
C {devices/gnd.sym} 1650 -1707.5 2 0 {name=l40 lab=GND}
C {devices/opin.sym} 1950 -1727.5 0 0 {name=p173 lab=OUT3}
C {devices/opin.sym} 1950 -1707.5 0 0 {name=p158 lab=OUT2}
C {devices/opin.sym} 1950 -1687.5 0 0 {name=p159 lab=OUT1}
C {devices/opin.sym} 1950 -1667.5 0 0 {name=p160 lab=OUT0}
C {devices/ipin.sym} 50 -1445 2 0 {name=p162 lab=VDD}
C {devices/ipin.sym} 50 -1285 2 0 {name=p174 lab=GND}
C {devices/vdd.sym} 50 -1445 0 0 {name=l41 lab=VDD}
C {devices/gnd.sym} 50 -1285 0 1 {name=l42 lab=GND}
C {devices/ipin.sym} 200 -1440 2 0 {name=p116 lab=VIN}
C {devices/vdd.sym} 200 -1440 0 0 {name=l18 lab=VIN}
C {devices/ipin.sym} 207.5 -1285 2 0 {name=p118 lab=CLK}
C {devices/vdd.sym} 207.5 -1285 0 0 {name=l44 lab=CLK}
C {devices/ipin.sym} 593.75 -2420 1 0 {name=p1 lab=VFS}
C {devices/ipin.sym} 593.75 -681.25 3 0 {name=p98 lab=VL}
C {/foss/designs/Analog_FA23_SP24/PTAT/xschem/PTAT_v0p0p0.sym} 633.75 -2542.5 0 0 {name=x18}
C {devices/vdd.sym} 1650 -1727.5 3 0 {name=l135 lab=VDD}
C {devices/vdd.sym} 1650 -1687.5 3 0 {name=l136 lab=VDD}
C {devices/vdd.sym} 783.75 -2552.5 1 0 {name=l137 lab=IB}
C {devices/vdd.sym} 483.75 -2552.5 3 0 {name=l43 lab=VDD}
C {devices/gnd.sym} 483.75 -2532.5 1 0 {name=l138 lab=GND}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -2495 0 0 {name=x67}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -2365 0 0 {name=x2}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -2235 0 0 {name=x3}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -2105 0 0 {name=x4}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1975 0 0 {name=x5}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1845 0 0 {name=x6}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1715 0 0 {name=x7}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1585 0 0 {name=x8}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1455 0 0 {name=x9}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1325 0 0 {name=x10}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1195 0 0 {name=x11}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1065 0 0 {name=x12}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -935 0 0 {name=x13}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -805 0 0 {name=x14}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -675 0 0 {name=x15}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -545 0 0 {name=x16}
C {devices/vdd.sym} 947.5 -2445 3 0 {name=l1 lab=IB}
C {devices/vdd.sym} 947.5 -2545 3 0 {name=l2 lab=VDD}
C {devices/gnd.sym} 947.5 -2525 2 0 {name=l3 lab=GND}
C {devices/vdd.sym} 947.5 -2485 3 0 {name=l4 lab=VIN}
C {devices/vdd.sym} 947.5 -2465 3 0 {name=l5 lab=CLK}
C {devices/vdd.sym} 947.5 -2315 3 0 {name=l6 lab=IB}
C {devices/vdd.sym} 947.5 -2415 3 0 {name=l7 lab=VDD}
C {devices/gnd.sym} 947.5 -2395 2 0 {name=l8 lab=GND}
C {devices/vdd.sym} 947.5 -2355 3 0 {name=l9 lab=VIN}
C {devices/vdd.sym} 947.5 -2335 3 0 {name=l10 lab=CLK}
C {devices/vdd.sym} 947.5 -2185 3 0 {name=l11 lab=IB}
C {devices/vdd.sym} 947.5 -2285 3 0 {name=l12 lab=VDD}
C {devices/gnd.sym} 947.5 -2265 2 0 {name=l13 lab=GND}
C {devices/vdd.sym} 947.5 -2225 3 0 {name=l14 lab=VIN}
C {devices/vdd.sym} 947.5 -2205 3 0 {name=l15 lab=CLK}
C {devices/vdd.sym} 947.5 -2055 3 0 {name=l22 lab=IB}
C {devices/vdd.sym} 947.5 -2155 3 0 {name=l23 lab=VDD}
C {devices/gnd.sym} 947.5 -2135 2 0 {name=l24 lab=GND}
C {devices/vdd.sym} 947.5 -2095 3 0 {name=l25 lab=VIN}
C {devices/vdd.sym} 947.5 -2075 3 0 {name=l26 lab=CLK}
C {devices/vdd.sym} 947.5 -1925 3 0 {name=l27 lab=IB}
C {devices/vdd.sym} 947.5 -2025 3 0 {name=l28 lab=VDD}
C {devices/gnd.sym} 947.5 -2005 2 0 {name=l29 lab=GND}
C {devices/vdd.sym} 947.5 -1965 3 0 {name=l30 lab=VIN}
C {devices/vdd.sym} 947.5 -1945 3 0 {name=l31 lab=CLK}
C {devices/vdd.sym} 947.5 -1795 3 0 {name=l32 lab=IB}
C {devices/vdd.sym} 947.5 -1895 3 0 {name=l33 lab=VDD}
C {devices/gnd.sym} 947.5 -1875 2 0 {name=l34 lab=GND}
C {devices/vdd.sym} 947.5 -1835 3 0 {name=l35 lab=VIN}
C {devices/vdd.sym} 947.5 -1815 3 0 {name=l36 lab=CLK}
C {devices/vdd.sym} 947.5 -1665 3 0 {name=l37 lab=IB}
C {devices/vdd.sym} 947.5 -1765 3 0 {name=l38 lab=VDD}
C {devices/gnd.sym} 947.5 -1745 2 0 {name=l39 lab=GND}
C {devices/vdd.sym} 947.5 -1705 3 0 {name=l45 lab=VIN}
C {devices/vdd.sym} 947.5 -1685 3 0 {name=l46 lab=CLK}
C {devices/vdd.sym} 947.5 -1535 3 0 {name=l47 lab=IB}
C {devices/vdd.sym} 947.5 -1635 3 0 {name=l48 lab=VDD}
C {devices/gnd.sym} 947.5 -1615 2 0 {name=l49 lab=GND}
C {devices/vdd.sym} 947.5 -1575 3 0 {name=l50 lab=VIN}
C {devices/vdd.sym} 947.5 -1555 3 0 {name=l51 lab=CLK}
C {devices/vdd.sym} 947.5 -1405 3 0 {name=l52 lab=IB}
C {devices/vdd.sym} 947.5 -1505 3 0 {name=l53 lab=VDD}
C {devices/gnd.sym} 947.5 -1485 2 0 {name=l54 lab=GND}
C {devices/vdd.sym} 947.5 -1445 3 0 {name=l55 lab=VIN}
C {devices/vdd.sym} 947.5 -1425 3 0 {name=l56 lab=CLK}
C {devices/vdd.sym} 947.5 -1275 3 0 {name=l57 lab=IB}
C {devices/vdd.sym} 947.5 -1375 3 0 {name=l58 lab=VDD}
C {devices/gnd.sym} 947.5 -1355 2 0 {name=l59 lab=GND}
C {devices/vdd.sym} 947.5 -1315 3 0 {name=l60 lab=VIN}
C {devices/vdd.sym} 947.5 -1295 3 0 {name=l61 lab=CLK}
C {devices/vdd.sym} 947.5 -1145 3 0 {name=l67 lab=IB}
C {devices/vdd.sym} 947.5 -1245 3 0 {name=l68 lab=VDD}
C {devices/gnd.sym} 947.5 -1225 2 0 {name=l69 lab=GND}
C {devices/vdd.sym} 947.5 -1185 3 0 {name=l70 lab=VIN}
C {devices/vdd.sym} 947.5 -1165 3 0 {name=l71 lab=CLK}
C {devices/vdd.sym} 947.5 -1015 3 0 {name=l72 lab=IB}
C {devices/vdd.sym} 947.5 -1115 3 0 {name=l73 lab=VDD}
C {devices/gnd.sym} 947.5 -1095 2 0 {name=l74 lab=GND}
C {devices/vdd.sym} 947.5 -1055 3 0 {name=l75 lab=VIN}
C {devices/vdd.sym} 947.5 -1035 3 0 {name=l76 lab=CLK}
C {devices/vdd.sym} 947.5 -885 3 0 {name=l77 lab=IB}
C {devices/vdd.sym} 947.5 -985 3 0 {name=l78 lab=VDD}
C {devices/gnd.sym} 947.5 -965 2 0 {name=l79 lab=GND}
C {devices/vdd.sym} 947.5 -925 3 0 {name=l80 lab=VIN}
C {devices/vdd.sym} 947.5 -905 3 0 {name=l81 lab=CLK}
C {devices/vdd.sym} 947.5 -755 3 0 {name=l82 lab=IB}
C {devices/vdd.sym} 947.5 -855 3 0 {name=l83 lab=VDD}
C {devices/gnd.sym} 947.5 -835 2 0 {name=l84 lab=GND}
C {devices/vdd.sym} 947.5 -795 3 0 {name=l85 lab=VIN}
C {devices/vdd.sym} 947.5 -775 3 0 {name=l86 lab=CLK}
C {devices/vdd.sym} 947.5 -625 3 0 {name=l87 lab=IB}
C {devices/vdd.sym} 947.5 -725 3 0 {name=l88 lab=VDD}
C {devices/gnd.sym} 947.5 -705 2 0 {name=l89 lab=GND}
C {devices/vdd.sym} 947.5 -665 3 0 {name=l90 lab=VIN}
C {devices/vdd.sym} 947.5 -645 3 0 {name=l91 lab=CLK}
C {devices/vdd.sym} 947.5 -495 3 0 {name=l92 lab=IB}
C {devices/vdd.sym} 947.5 -595 3 0 {name=l93 lab=VDD}
C {devices/gnd.sym} 947.5 -575 2 0 {name=l94 lab=GND}
C {devices/vdd.sym} 947.5 -535 3 0 {name=l95 lab=VIN}
C {devices/vdd.sym} 947.5 -515 3 0 {name=l96 lab=CLK}
