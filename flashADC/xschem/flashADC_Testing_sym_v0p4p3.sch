v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 593.75 -901.25 593.75 -881.25 {
lab=#net1}
N 593.75 -801.25 593.75 -781.25 {
lab=#net2}
N 593.75 -701.25 593.75 -681.25 {
lab=VL}
N 593.75 -1001.25 593.75 -981.25 {
lab=#net3}
N 593.75 -1101.25 593.75 -1081.25 {
lab=#net4}
N 593.75 -1201.25 593.75 -1181.25 {
lab=#net5}
N 593.75 -1301.25 593.75 -1281.25 {
lab=#net6}
N 593.75 -1401.25 593.75 -1381.25 {
lab=#net7}
N 593.75 -1501.25 593.75 -1481.25 {
lab=#net8}
N 593.75 -1601.25 593.75 -1581.25 {
lab=#net9}
N 593.75 -1701.25 593.75 -1681.25 {
lab=#net10}
N 593.75 -1801.25 593.75 -1781.25 {
lab=#net11}
N 593.75 -1901.25 593.75 -1881.25 {
lab=#net12}
N 593.75 -2001.25 593.75 -1981.25 {
lab=#net13}
N 593.75 -2101.25 593.75 -2081.25 {
lab=#net14}
N 593.75 -2201.25 593.75 -2181.25 {
lab=#net15}
N 593.75 -2301.25 593.75 -2281.25 {
lab=#net16}
N 533.75 -2251.25 573.75 -2251.25 {
lab=VL}
N 533.75 -2251.25 533.75 -2151.25 {
lab=VL}
N 533.75 -2151.25 573.75 -2151.25 {
lab=VL}
N 533.75 -2051.25 573.75 -2051.25 {
lab=VL}
N 533.75 -1951.25 573.75 -1951.25 {
lab=VL}
N 533.75 -1851.25 573.75 -1851.25 {
lab=VL}
N 533.75 -1751.25 573.75 -1751.25 {
lab=VL}
N 533.75 -1651.25 573.75 -1651.25 {
lab=VL}
N 533.75 -1551.25 573.75 -1551.25 {
lab=VL}
N 533.75 -1451.25 573.75 -1451.25 {
lab=VL}
N 533.75 -1351.25 573.75 -1351.25 {
lab=VL}
N 533.75 -1251.25 573.75 -1251.25 {
lab=VL}
N 533.75 -1151.25 573.75 -1151.25 {
lab=VL}
N 533.75 -1051.25 573.75 -1051.25 {
lab=VL}
N 533.75 -951.25 573.75 -951.25 {
lab=VL}
N 533.75 -851.25 573.75 -851.25 {
lab=VL}
N 533.75 -751.25 573.75 -751.25 {
lab=VL}
N 533.75 -701.25 593.75 -701.25 {
lab=VL}
N 533.75 -751.25 533.75 -701.25 {
lab=VL}
N 533.75 -951.25 533.75 -851.25 {
lab=VL}
N 533.75 -1051.25 533.75 -951.25 {
lab=VL}
N 593.75 -801.25 813.75 -801.25 {
lab=#net2}
N 593.75 -2421.25 593.75 -2381.25 {
lab=VFS}
N 533.75 -2351.25 573.75 -2351.25 {
lab=VL}
N 533.75 -2351.25 533.75 -2251.25 {
lab=VL}
N 593.75 -901.25 830 -901.25 {
lab=#net1}
N 593.75 -1001.25 841.25 -1001.25 {
lab=#net3}
N 593.75 -1101.25 852.5 -1101.25 {
lab=#net4}
N 593.75 -1201.25 861.25 -1201.25 {
lab=#net5}
N 593.75 -1301.25 871.25 -1301.25 {
lab=#net6}
N 593.75 -1401.25 856.25 -1401.25 {
lab=#net7}
N 593.75 -1501.25 813.75 -1501.25 {
lab=#net8}
N 593.75 -1601.25 932.5 -1601.25 {
lab=#net9}
N 593.75 -1701.25 813.75 -1701.25 {
lab=#net10}
N 593.75 -1801.25 813.75 -1801.25 {
lab=#net11}
N 593.75 -1901.25 817.5 -1901.25 {
lab=#net12}
N 593.75 -2001.25 838.75 -2001.25 {
lab=#net13}
N 593.75 -2101.25 835 -2101.25 {
lab=#net14}
N 593.75 -2201.25 821.25 -2201.25 {
lab=#net15}
N 593.75 -2301.25 813.75 -2301.25 {
lab=#net16}
N 533.75 -2151.25 533.75 -2051.25 {
lab=VL}
N 533.75 -2051.25 533.75 -1951.25 {
lab=VL}
N 533.75 -1951.25 533.75 -1851.25 {
lab=VL}
N 533.75 -1851.25 533.75 -1751.25 {
lab=VL}
N 533.75 -1751.25 533.75 -1651.25 {
lab=VL}
N 533.75 -1651.25 533.75 -1551.25 {
lab=VL}
N 533.75 -1551.25 533.75 -1451.25 {
lab=VL}
N 533.75 -1451.25 533.75 -1351.25 {
lab=VL}
N 533.75 -1351.25 533.75 -1251.25 {
lab=VL}
N 533.75 -1251.25 533.75 -1151.25 {
lab=VL}
N 533.75 -1151.25 533.75 -1051.25 {
lab=VL}
N 533.75 -851.25 533.75 -751.25 {
lab=VL}
N 593.75 -721.25 593.75 -701.25 {
lab=VL}
N 593.75 -821.25 593.75 -801.25 {
lab=#net2}
N 593.75 -921.25 593.75 -901.25 {
lab=#net1}
N 593.75 -1021.25 593.75 -1001.25 {
lab=#net3}
N 593.75 -1121.25 593.75 -1101.25 {
lab=#net4}
N 593.75 -1221.25 593.75 -1201.25 {
lab=#net5}
N 593.75 -1321.25 593.75 -1301.25 {
lab=#net6}
N 593.75 -1421.25 593.75 -1401.25 {
lab=#net7}
N 593.75 -1521.25 593.75 -1501.25 {
lab=#net8}
N 593.75 -1621.25 593.75 -1601.25 {
lab=#net9}
N 593.75 -1721.25 593.75 -1701.25 {
lab=#net10}
N 593.75 -1821.25 593.75 -1801.25 {
lab=#net11}
N 593.75 -1921.25 593.75 -1901.25 {
lab=#net12}
N 593.75 -2021.25 593.75 -2001.25 {
lab=#net13}
N 593.75 -2121.25 593.75 -2101.25 {
lab=#net14}
N 593.75 -2221.25 593.75 -2201.25 {
lab=#net15}
N 593.75 -2321.25 593.75 -2301.25 {
lab=#net16}
N 813.75 -2505 947.5 -2505 {
lab=#net16}
N 813.75 -2505 813.75 -2301.25 {
lab=#net16}
N 821.25 -2375 821.25 -2201.25 {
lab=#net15}
N 821.25 -2375 947.5 -2375 {
lab=#net15}
N 835 -2245 835 -2101.25 {
lab=#net14}
N 835 -2245 948.75 -2245 {
lab=#net14}
N 838.75 -2115 838.75 -2001.25 {
lab=#net13}
N 838.75 -2115 947.5 -2115 {
lab=#net13}
N 817.5 -1985 947.5 -1985 {
lab=#net12}
N 817.5 -1985 817.5 -1901.25 {
lab=#net12}
N 813.75 -1855 947.5 -1855 {
lab=#net11}
N 813.75 -1855 813.75 -1801.25 {
lab=#net11}
N 813.75 -1725 947.5 -1725 {
lab=#net10}
N 813.75 -1725 813.75 -1701.25 {
lab=#net10}
N 932.5 -1601.25 932.5 -1595 {
lab=#net9}
N 932.5 -1595 947.5 -1595 {
lab=#net9}
N 813.75 -1501.25 813.75 -1465 {
lab=#net8}
N 813.75 -1465 947.5 -1465 {
lab=#net8}
N 856.25 -1401.25 856.25 -1335 {
lab=#net7}
N 856.25 -1335 947.5 -1335 {
lab=#net7}
N 871.25 -1301.25 871.25 -1205 {
lab=#net6}
N 871.25 -1205 947.5 -1205 {
lab=#net6}
N 861.25 -1201.25 861.25 -1075 {
lab=#net5}
N 861.25 -1075 947.5 -1075 {
lab=#net5}
N 852.5 -1101.25 852.5 -945 {
lab=#net4}
N 852.5 -945 947.5 -945 {
lab=#net4}
N 841.25 -1001.25 841.25 -815 {
lab=#net3}
N 841.25 -815 947.5 -815 {
lab=#net3}
N 830 -901.25 830 -685 {
lab=#net1}
N 830 -685 947.5 -685 {
lab=#net1}
N 813.75 -801.25 813.75 -555 {
lab=#net2}
N 813.75 -555 948.75 -555 {
lab=#net2}
N 1245 -2545 1500 -2545 {
lab=#net17}
N 1500 -2545 1500 -1667.5 {
lab=#net17}
N 1500 -1667.5 1650 -1667.5 {
lab=#net17}
N 1247.5 -2415 1487.5 -2415 {
lab=#net18}
N 1487.5 -2415 1487.5 -1647.5 {
lab=#net18}
N 1487.5 -1647.5 1650 -1647.5 {
lab=#net18}
N 1247.5 -2285 1475 -2285 {
lab=#net19}
N 1475 -2285 1475 -1627.5 {
lab=#net19}
N 1475 -1627.5 1650 -1627.5 {
lab=#net19}
N 1247.5 -2155 1457.5 -2155 {
lab=#net20}
N 1457.5 -2155 1457.5 -1607.5 {
lab=#net20}
N 1457.5 -1607.5 1650 -1607.5 {
lab=#net20}
N 1247.5 -2025 1447.5 -2025 {
lab=#net21}
N 1447.5 -2025 1447.5 -1587.5 {
lab=#net21}
N 1447.5 -1587.5 1650 -1587.5 {
lab=#net21}
N 1247.5 -1895 1432.5 -1895 {
lab=#net22}
N 1432.5 -1895 1432.5 -1567.5 {
lab=#net22}
N 1432.5 -1567.5 1650 -1567.5 {
lab=#net22}
N 1247.5 -1765 1425 -1765 {
lab=#net23}
N 1425 -1765 1425 -1547.5 {
lab=#net23}
N 1425 -1547.5 1650 -1547.5 {
lab=#net23}
N 1247.5 -1635 1410 -1635 {
lab=#net24}
N 1410 -1635 1410 -1527.5 {
lab=#net24}
N 1410 -1527.5 1650 -1527.5 {
lab=#net24}
N 1247.5 -1505 1632.5 -1505 {
lab=#net25}
N 1632.5 -1507.5 1632.5 -1505 {
lab=#net25}
N 1632.5 -1507.5 1650 -1507.5 {
lab=#net25}
N 1247.5 -1375 1277.5 -1375 {
lab=#net26}
N 1277.5 -1487.5 1277.5 -1375 {
lab=#net26}
N 1277.5 -1487.5 1650 -1487.5 {
lab=#net26}
N 1247.5 -1245 1295 -1245 {
lab=#net27}
N 1295 -1467.5 1295 -1245 {
lab=#net27}
N 1295 -1467.5 1650 -1467.5 {
lab=#net27}
N 1247.5 -1115 1330 -1115 {
lab=#net28}
N 1330 -1447.5 1330 -1115 {
lab=#net28}
N 1330 -1447.5 1650 -1447.5 {
lab=#net28}
N 1247.5 -985 1362.5 -985 {
lab=#net29}
N 1362.5 -1427.5 1362.5 -985 {
lab=#net29}
N 1362.5 -1427.5 1650 -1427.5 {
lab=#net29}
N 1247.5 -855 1407.5 -855 {
lab=#net30}
N 1407.5 -1407.5 1407.5 -855 {
lab=#net30}
N 1407.5 -1407.5 1650 -1407.5 {
lab=#net30}
N 1247.5 -725 1432.5 -725 {
lab=#net31}
N 1432.5 -1387.5 1432.5 -725 {
lab=#net31}
N 1432.5 -1387.5 1650 -1387.5 {
lab=#net31}
N 1247.5 -595 1472.5 -595 {
lab=#net32}
N 1472.5 -1367.5 1472.5 -595 {
lab=#net32}
N 1472.5 -1367.5 1650 -1367.5 {
lab=#net32}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -751.25 0 0 {name=R1
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -851.25 0 0 {name=R2
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -951.25 0 0 {name=R3
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1051.25 0 0 {name=R4
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1151.25 0 0 {name=R5
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1251.25 0 0 {name=R6
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1351.25 0 0 {name=R7
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1451.25 0 0 {name=R8
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1551.25 0 0 {name=R9
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1651.25 0 0 {name=R10
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1751.25 0 0 {name=R11
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1851.25 0 0 {name=R12
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1951.25 0 0 {name=R13
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2051.25 0 0 {name=R14
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2151.25 0 0 {name=R15
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2251.25 0 0 {name=R16
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2351.25 0 0 {name=R18
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {devices/code.sym} 93.75 -1138.75 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {/foss/designs/Analog_FA23_SP24/PriorityEncoder/xschem/16to4_PriorityEncoder_v0p0p1.sym} 1800 -1547.5 0 0 {name=x1}
C {devices/gnd.sym} 1650 -1707.5 1 0 {name=l40 lab=GND}
C {devices/opin.sym} 1950 -1727.5 0 0 {name=p173 lab=OUT3}
C {devices/opin.sym} 1950 -1707.5 0 0 {name=p158 lab=OUT2}
C {devices/opin.sym} 1950 -1687.5 0 0 {name=p159 lab=OUT1}
C {devices/opin.sym} 1950 -1667.5 0 0 {name=p160 lab=OUT0}
C {devices/ipin.sym} 50 -1445 2 0 {name=p162 lab=VDD}
C {devices/ipin.sym} 50 -1285 2 0 {name=p174 lab=GND}
C {devices/vdd.sym} 50 -1445 0 0 {name=l41 lab=VDD}
C {devices/gnd.sym} 50 -1285 0 1 {name=l42 lab=GND}
C {devices/ipin.sym} 200 -1440 2 0 {name=p116 lab=VIN}
C {devices/ipin.sym} 207.5 -1285 2 0 {name=p118 lab=CLK}
C {devices/ipin.sym} 593.75 -2420 1 0 {name=p1 lab=VFS}
C {devices/ipin.sym} 593.75 -681.25 3 0 {name=p98 lab=VL}
C {/foss/designs/Analog_FA23_SP24/PTAT/xschem/PTAT_v0p0p0.sym} 633.75 -2542.5 0 0 {name=x18}
C {devices/vdd.sym} 483.75 -2552.5 3 0 {name=l43 lab=VDD}
C {devices/gnd.sym} 483.75 -2532.5 1 0 {name=l138 lab=GND}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -2495 0 0 {name=x67}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -2365 0 0 {name=x2}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -2235 0 0 {name=x3}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -2105 0 0 {name=x4}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1975 0 0 {name=x5}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1845 0 0 {name=x6}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1715 0 0 {name=x7}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1585 0 0 {name=x8}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1455 0 0 {name=x9}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1325 0 0 {name=x10}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1195 0 0 {name=x11}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -1065 0 0 {name=x12}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -935 0 0 {name=x13}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -805 0 0 {name=x14}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -675 0 0 {name=x15}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1097.5 -545 0 0 {name=x16}
C {devices/gnd.sym} 947.5 -2525 1 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 200 -1440 0 0 {name=p2 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 50 -1445 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 207.5 -1285 0 0 {name=p4 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 783.75 -2552.5 2 0 {name=p7 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -2445 0 0 {name=p8 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -2465 0 0 {name=p9 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -2485 0 0 {name=p10 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -2545 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -2395 1 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 947.5 -2315 0 0 {name=p6 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -2335 0 0 {name=p11 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -2355 0 0 {name=p12 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -2415 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -2265 1 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 947.5 -2185 0 0 {name=p14 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -2205 0 0 {name=p15 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -2225 0 0 {name=p16 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -2285 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -2135 1 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} 947.5 -2055 0 0 {name=p18 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -2075 0 0 {name=p19 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -2095 0 0 {name=p20 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -2155 0 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -2005 1 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 947.5 -1925 0 0 {name=p22 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -1945 0 0 {name=p23 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -1965 0 0 {name=p24 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -2025 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -1875 1 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} 947.5 -1795 0 0 {name=p26 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -1815 0 0 {name=p27 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -1835 0 0 {name=p28 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -1895 0 0 {name=p29 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -1745 1 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 947.5 -1665 0 0 {name=p30 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -1685 0 0 {name=p31 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -1705 0 0 {name=p32 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -1765 0 0 {name=p33 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -1615 1 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 947.5 -1535 0 0 {name=p34 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -1555 0 0 {name=p35 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -1575 0 0 {name=p36 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -1635 0 0 {name=p37 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -1485 1 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 947.5 -1405 0 0 {name=p38 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -1425 0 0 {name=p39 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -1445 0 0 {name=p40 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -1505 0 0 {name=p41 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -1355 1 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 947.5 -1275 0 0 {name=p42 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -1295 0 0 {name=p43 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -1315 0 0 {name=p44 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -1375 0 0 {name=p45 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -1225 1 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 947.5 -1145 0 0 {name=p46 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -1165 0 0 {name=p47 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -1185 0 0 {name=p48 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -1245 0 0 {name=p49 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -1095 1 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} 947.5 -1015 0 0 {name=p50 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -1035 0 0 {name=p51 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -1055 0 0 {name=p52 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -1115 0 0 {name=p53 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -965 1 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 947.5 -885 0 0 {name=p54 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -905 0 0 {name=p55 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -925 0 0 {name=p56 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -985 0 0 {name=p57 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -835 1 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 947.5 -755 0 0 {name=p58 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -775 0 0 {name=p59 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -795 0 0 {name=p60 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -855 0 0 {name=p61 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -705 1 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} 947.5 -625 0 0 {name=p62 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -645 0 0 {name=p63 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -665 0 0 {name=p64 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -725 0 0 {name=p65 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 947.5 -575 1 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 947.5 -495 0 0 {name=p66 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 947.5 -515 0 0 {name=p67 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 947.5 -535 0 0 {name=p68 sig_type=std_logic lab=VIN
}
C {devices/lab_pin.sym} 947.5 -595 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1650 -1727.5 0 0 {name=p70 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1650 -1687.5 0 0 {name=p71 sig_type=std_logic lab=VDD}
