v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 593.75 -901.25 593.75 -881.25 {
lab=#net1}
N 593.75 -801.25 593.75 -781.25 {
lab=#net2}
N 593.75 -701.25 593.75 -681.25 {
lab=VL}
N 593.75 -1001.25 593.75 -981.25 {
lab=#net3}
N 593.75 -1101.25 593.75 -1081.25 {
lab=#net4}
N 593.75 -1201.25 593.75 -1181.25 {
lab=#net5}
N 593.75 -1301.25 593.75 -1281.25 {
lab=#net6}
N 593.75 -1401.25 593.75 -1381.25 {
lab=#net7}
N 593.75 -1501.25 593.75 -1481.25 {
lab=#net8}
N 593.75 -1601.25 593.75 -1581.25 {
lab=#net9}
N 593.75 -1701.25 593.75 -1681.25 {
lab=#net10}
N 593.75 -1801.25 593.75 -1781.25 {
lab=#net11}
N 593.75 -1901.25 593.75 -1881.25 {
lab=#net12}
N 593.75 -2001.25 593.75 -1981.25 {
lab=#net13}
N 593.75 -2101.25 593.75 -2081.25 {
lab=#net14}
N 593.75 -2201.25 593.75 -2181.25 {
lab=#net15}
N 593.75 -2301.25 593.75 -2281.25 {
lab=#net16}
N 533.75 -2251.25 573.75 -2251.25 {
lab=VL}
N 533.75 -2251.25 533.75 -2151.25 {
lab=VL}
N 533.75 -2151.25 573.75 -2151.25 {
lab=VL}
N 533.75 -2051.25 573.75 -2051.25 {
lab=VL}
N 533.75 -1951.25 573.75 -1951.25 {
lab=VL}
N 533.75 -1851.25 573.75 -1851.25 {
lab=VL}
N 533.75 -1751.25 573.75 -1751.25 {
lab=VL}
N 533.75 -1651.25 573.75 -1651.25 {
lab=VL}
N 533.75 -1551.25 573.75 -1551.25 {
lab=VL}
N 533.75 -1451.25 573.75 -1451.25 {
lab=VL}
N 533.75 -1351.25 573.75 -1351.25 {
lab=VL}
N 533.75 -1251.25 573.75 -1251.25 {
lab=VL}
N 533.75 -1151.25 573.75 -1151.25 {
lab=VL}
N 533.75 -1051.25 573.75 -1051.25 {
lab=VL}
N 533.75 -951.25 573.75 -951.25 {
lab=VL}
N 533.75 -851.25 573.75 -851.25 {
lab=VL}
N 533.75 -751.25 573.75 -751.25 {
lab=VL}
N 533.75 -701.25 593.75 -701.25 {
lab=VL}
N 533.75 -751.25 533.75 -701.25 {
lab=VL}
N 533.75 -951.25 533.75 -851.25 {
lab=VL}
N 533.75 -1051.25 533.75 -951.25 {
lab=VL}
N 593.75 -801.25 813.75 -801.25 {
lab=#net2}
N 593.75 -2421.25 593.75 -2381.25 {
lab=VFS}
N 533.75 -2351.25 573.75 -2351.25 {
lab=VL}
N 533.75 -2351.25 533.75 -2251.25 {
lab=VL}
N 773.75 -761.25 813.75 -761.25 {
lab=IB}
N 773.75 -781.25 813.75 -781.25 {
lab=VIN}
N 1113.75 -801.25 1153.75 -801.25 {
lab=VDD}
N 1113.75 -781.25 1223.75 -781.25 {
lab=#net17}
N 1113.75 -761.25 1223.75 -761.25 {
lab=#net18}
N 1113.75 -741.25 1153.75 -741.25 {
lab=GND}
N 1113.75 -901.25 1153.75 -901.25 {
lab=VDD}
N 1113.75 -881.25 1223.75 -881.25 {
lab=#net19}
N 1113.75 -861.25 1223.75 -861.25 {
lab=#net20}
N 1113.75 -841.25 1153.75 -841.25 {
lab=GND}
N 1113.75 -1001.25 1153.75 -1001.25 {
lab=VDD}
N 1113.75 -981.25 1223.75 -981.25 {
lab=#net21}
N 1113.75 -961.25 1223.75 -961.25 {
lab=#net22}
N 1113.75 -941.25 1153.75 -941.25 {
lab=GND}
N 1113.75 -1101.25 1153.75 -1101.25 {
lab=VDD}
N 1113.75 -1081.25 1223.75 -1081.25 {
lab=#net23}
N 1113.75 -1061.25 1223.75 -1061.25 {
lab=#net24}
N 1113.75 -1041.25 1153.75 -1041.25 {
lab=GND}
N 1113.75 -1201.25 1153.75 -1201.25 {
lab=VDD}
N 1113.75 -1181.25 1223.75 -1181.25 {
lab=#net25}
N 1113.75 -1161.25 1223.75 -1161.25 {
lab=#net26}
N 1113.75 -1141.25 1153.75 -1141.25 {
lab=GND}
N 1113.75 -1301.25 1153.75 -1301.25 {
lab=VDD}
N 1113.75 -1281.25 1223.75 -1281.25 {
lab=#net27}
N 1113.75 -1261.25 1223.75 -1261.25 {
lab=#net28}
N 1113.75 -1241.25 1153.75 -1241.25 {
lab=GND}
N 1113.75 -1401.25 1153.75 -1401.25 {
lab=VDD}
N 1113.75 -1381.25 1223.75 -1381.25 {
lab=#net29}
N 1113.75 -1361.25 1223.75 -1361.25 {
lab=#net30}
N 1113.75 -1341.25 1153.75 -1341.25 {
lab=GND}
N 1113.75 -1501.25 1153.75 -1501.25 {
lab=VDD}
N 1113.75 -1481.25 1223.75 -1481.25 {
lab=#net31}
N 1113.75 -1461.25 1223.75 -1461.25 {
lab=#net32}
N 1113.75 -1441.25 1153.75 -1441.25 {
lab=GND}
N 1113.75 -1601.25 1153.75 -1601.25 {
lab=VDD}
N 1113.75 -1581.25 1223.75 -1581.25 {
lab=#net33}
N 1113.75 -1561.25 1223.75 -1561.25 {
lab=#net34}
N 1113.75 -1541.25 1153.75 -1541.25 {
lab=GND}
N 1113.75 -1701.25 1153.75 -1701.25 {
lab=VDD}
N 1113.75 -1681.25 1223.75 -1681.25 {
lab=#net35}
N 1113.75 -1661.25 1223.75 -1661.25 {
lab=#net36}
N 1113.75 -1641.25 1153.75 -1641.25 {
lab=GND}
N 1113.75 -1801.25 1153.75 -1801.25 {
lab=VDD}
N 1113.75 -1781.25 1223.75 -1781.25 {
lab=#net37}
N 1113.75 -1761.25 1223.75 -1761.25 {
lab=#net38}
N 1113.75 -1741.25 1153.75 -1741.25 {
lab=GND}
N 1113.75 -1901.25 1153.75 -1901.25 {
lab=VDD}
N 1113.75 -1881.25 1223.75 -1881.25 {
lab=#net39}
N 1113.75 -1861.25 1223.75 -1861.25 {
lab=#net40}
N 1113.75 -1841.25 1153.75 -1841.25 {
lab=GND}
N 1113.75 -2001.25 1153.75 -2001.25 {
lab=VDD}
N 1113.75 -1981.25 1223.75 -1981.25 {
lab=#net41}
N 1113.75 -1961.25 1223.75 -1961.25 {
lab=#net42}
N 1113.75 -1941.25 1153.75 -1941.25 {
lab=GND}
N 1113.75 -2101.25 1153.75 -2101.25 {
lab=VDD}
N 1113.75 -2081.25 1223.75 -2081.25 {
lab=#net43}
N 1113.75 -2061.25 1223.75 -2061.25 {
lab=#net44}
N 1113.75 -2041.25 1153.75 -2041.25 {
lab=GND}
N 1113.75 -2201.25 1153.75 -2201.25 {
lab=VDD}
N 1113.75 -2181.25 1223.75 -2181.25 {
lab=#net45}
N 1113.75 -2161.25 1223.75 -2161.25 {
lab=#net46}
N 1113.75 -2141.25 1153.75 -2141.25 {
lab=GND}
N 1113.75 -2301.25 1153.75 -2301.25 {
lab=VDD}
N 1113.75 -2281.25 1223.75 -2281.25 {
lab=#net47}
N 1113.75 -2261.25 1223.75 -2261.25 {
lab=#net48}
N 1113.75 -2241.25 1153.75 -2241.25 {
lab=GND}
N 773.75 -741.25 813.75 -741.25 {
lab=CLK}
N 593.75 -901.25 813.75 -901.25 {
lab=#net1}
N 773.75 -861.25 813.75 -861.25 {
lab=IB}
N 773.75 -881.25 813.75 -881.25 {
lab=VIN}
N 773.75 -841.25 813.75 -841.25 {
lab=CLK}
N 593.75 -1001.25 813.75 -1001.25 {
lab=#net3}
N 775 -961.25 815 -961.25 {
lab=IB}
N 775 -981.25 815 -981.25 {
lab=VIN}
N 775 -941.25 815 -941.25 {
lab=CLK}
N 593.75 -1101.25 813.75 -1101.25 {
lab=#net4}
N 773.75 -1061.25 813.75 -1061.25 {
lab=IB}
N 773.75 -1081.25 813.75 -1081.25 {
lab=VIN}
N 773.75 -1041.25 813.75 -1041.25 {
lab=CLK}
N 593.75 -1201.25 813.75 -1201.25 {
lab=#net5}
N 775 -1161.25 815 -1161.25 {
lab=IB}
N 775 -1181.25 815 -1181.25 {
lab=VIN}
N 775 -1141.25 815 -1141.25 {
lab=CLK}
N 593.75 -1301.25 813.75 -1301.25 {
lab=#net6}
N 773.75 -1261.25 813.75 -1261.25 {
lab=IB}
N 773.75 -1281.25 813.75 -1281.25 {
lab=VIN}
N 773.75 -1241.25 813.75 -1241.25 {
lab=CLK}
N 593.75 -1401.25 813.75 -1401.25 {
lab=#net7}
N 775 -1361.25 815 -1361.25 {
lab=IB}
N 775 -1381.25 815 -1381.25 {
lab=VIN}
N 775 -1341.25 815 -1341.25 {
lab=CLK}
N 593.75 -1501.25 813.75 -1501.25 {
lab=#net8}
N 773.75 -1461.25 813.75 -1461.25 {
lab=IB}
N 773.75 -1481.25 813.75 -1481.25 {
lab=VIN}
N 773.75 -1441.25 813.75 -1441.25 {
lab=CLK}
N 593.75 -1601.25 813.75 -1601.25 {
lab=#net9}
N 775 -1561.25 815 -1561.25 {
lab=IB}
N 775 -1581.25 815 -1581.25 {
lab=VIN}
N 775 -1541.25 815 -1541.25 {
lab=CLK}
N 593.75 -1701.25 813.75 -1701.25 {
lab=#net10}
N 773.75 -1661.25 813.75 -1661.25 {
lab=IB}
N 773.75 -1681.25 813.75 -1681.25 {
lab=VIN}
N 773.75 -1641.25 813.75 -1641.25 {
lab=CLK}
N 593.75 -1801.25 813.75 -1801.25 {
lab=#net11}
N 775 -1761.25 815 -1761.25 {
lab=IB}
N 775 -1781.25 815 -1781.25 {
lab=VIN}
N 775 -1741.25 815 -1741.25 {
lab=CLK}
N 593.75 -1901.25 813.75 -1901.25 {
lab=#net12}
N 773.75 -1861.25 813.75 -1861.25 {
lab=IB}
N 773.75 -1881.25 813.75 -1881.25 {
lab=VIN}
N 773.75 -1841.25 813.75 -1841.25 {
lab=CLK}
N 593.75 -2001.25 813.75 -2001.25 {
lab=#net13}
N 775 -1961.25 815 -1961.25 {
lab=IB}
N 775 -1981.25 815 -1981.25 {
lab=VIN}
N 775 -1941.25 815 -1941.25 {
lab=CLK}
N 593.75 -2101.25 813.75 -2101.25 {
lab=#net14}
N 773.75 -2061.25 813.75 -2061.25 {
lab=IB}
N 773.75 -2081.25 813.75 -2081.25 {
lab=VIN}
N 773.75 -2041.25 813.75 -2041.25 {
lab=CLK}
N 593.75 -2201.25 813.75 -2201.25 {
lab=#net15}
N 776.25 -2161.25 816.25 -2161.25 {
lab=IB}
N 776.25 -2181.25 816.25 -2181.25 {
lab=VIN}
N 776.25 -2141.25 816.25 -2141.25 {
lab=CLK}
N 593.75 -2301.25 813.75 -2301.25 {
lab=#net16}
N 773.75 -2261.25 813.75 -2261.25 {
lab=IB}
N 773.75 -2281.25 813.75 -2281.25 {
lab=VIN}
N 773.75 -2241.25 813.75 -2241.25 {
lab=CLK}
N 533.75 -2151.25 533.75 -2051.25 {
lab=VL}
N 533.75 -2051.25 533.75 -1951.25 {
lab=VL}
N 533.75 -1951.25 533.75 -1851.25 {
lab=VL}
N 533.75 -1851.25 533.75 -1751.25 {
lab=VL}
N 533.75 -1751.25 533.75 -1651.25 {
lab=VL}
N 533.75 -1651.25 533.75 -1551.25 {
lab=VL}
N 533.75 -1551.25 533.75 -1451.25 {
lab=VL}
N 533.75 -1451.25 533.75 -1351.25 {
lab=VL}
N 533.75 -1351.25 533.75 -1251.25 {
lab=VL}
N 533.75 -1251.25 533.75 -1151.25 {
lab=VL}
N 533.75 -1151.25 533.75 -1051.25 {
lab=VL}
N 533.75 -851.25 533.75 -751.25 {
lab=VL}
N 593.75 -721.25 593.75 -701.25 {
lab=VL}
N 593.75 -821.25 593.75 -801.25 {
lab=#net2}
N 593.75 -921.25 593.75 -901.25 {
lab=#net1}
N 593.75 -1021.25 593.75 -1001.25 {
lab=#net3}
N 593.75 -1121.25 593.75 -1101.25 {
lab=#net4}
N 593.75 -1221.25 593.75 -1201.25 {
lab=#net5}
N 593.75 -1321.25 593.75 -1301.25 {
lab=#net6}
N 593.75 -1421.25 593.75 -1401.25 {
lab=#net7}
N 593.75 -1521.25 593.75 -1501.25 {
lab=#net8}
N 593.75 -1621.25 593.75 -1601.25 {
lab=#net9}
N 593.75 -1721.25 593.75 -1701.25 {
lab=#net10}
N 593.75 -1821.25 593.75 -1801.25 {
lab=#net11}
N 593.75 -1921.25 593.75 -1901.25 {
lab=#net12}
N 593.75 -2021.25 593.75 -2001.25 {
lab=#net13}
N 593.75 -2121.25 593.75 -2101.25 {
lab=#net14}
N 593.75 -2221.25 593.75 -2201.25 {
lab=#net15}
N 593.75 -2321.25 593.75 -2301.25 {
lab=#net16}
N 1872.5 -1711.25 1872.5 -1661.25 {
lab=#net49}
N 1892.5 -1691.25 1892.5 -1561.25 {
lab=#net50}
N 1912.5 -1671.25 1912.5 -1461.25 {
lab=#net51}
N 1922.5 -1651.25 1922.5 -1361.25 {
lab=#net52}
N 1942.5 -1631.25 1942.5 -1261.25 {
lab=#net53}
N 1962.5 -1611.25 1962.5 -1161.25 {
lab=#net54}
N 1972.5 -1591.25 1972.5 -1061.25 {
lab=#net55}
N 1982.5 -1561.25 1982.5 -961.25 {
lab=#net56}
N 1982.5 -1571.25 1982.5 -1561.25 {
lab=#net56}
N 1992.5 -1551.25 1992.5 -861.25 {
lab=#net57}
N 2002.5 -1531.25 2002.5 -761.25 {
lab=#net58}
N 1602.5 -2261.25 1963.75 -2261.25 {
lab=#net59}
N 1963.75 -2261.25 1963.75 -2241.25 {
lab=#net59}
N 1602.5 -2161.25 1942.5 -2161.25 {
lab=#net60}
N 1942.5 -2161.25 1942.5 -2141.25 {
lab=#net60}
N 1602.5 -2061.25 1922.5 -2061.25 {
lab=#net61}
N 1922.5 -2061.25 1922.5 -2041.25 {
lab=#net61}
N 1602.5 -1961.25 1902.5 -1961.25 {
lab=#net62}
N 1902.5 -1961.25 1902.5 -1942.5 {
lab=#net62}
N 1602.5 -1861.25 1882.5 -1861.25 {
lab=#net63}
N 1882.5 -1861.25 1882.5 -1841.25 {
lab=#net63}
N 1602.5 -1761.25 1862.5 -1761.25 {
lab=#net64}
N 1862.5 -1761.25 1862.5 -1741.25 {
lab=#net64}
N 1602.5 -1661.25 1872.5 -1661.25 {
lab=#net49}
N 1602.5 -1561.25 1892.5 -1561.25 {
lab=#net50}
N 1602.5 -1461.25 1912.5 -1461.25 {
lab=#net51}
N 1602.5 -1361.25 1922.5 -1361.25 {
lab=#net52}
N 1602.5 -1261.25 1942.5 -1261.25 {
lab=#net53}
N 1602.5 -1161.25 1962.5 -1161.25 {
lab=#net54}
N 1602.5 -1061.25 1972.5 -1061.25 {
lab=#net55}
N 1602.5 -961.25 1982.5 -961.25 {
lab=#net56}
N 1602.5 -861.25 1992.5 -861.25 {
lab=#net57}
N 1602.5 -761.25 2002.5 -761.25 {
lab=#net58}
N 2002.5 -1532.5 2002.5 -1531.25 {
lab=#net58}
N 2002.5 -1532.5 2145 -1532.5 {
lab=#net58}
N 1992.5 -1552.5 1992.5 -1551.25 {
lab=#net57}
N 1992.5 -1552.5 2143.75 -1552.5 {
lab=#net57}
N 1982.5 -1572.5 1982.5 -1571.25 {
lab=#net56}
N 1982.5 -1572.5 2143.75 -1572.5 {
lab=#net56}
N 1972.5 -1592.5 1972.5 -1591.25 {
lab=#net55}
N 1972.5 -1592.5 2145 -1592.5 {
lab=#net55}
N 1962.5 -1612.5 1962.5 -1611.25 {
lab=#net54}
N 1962.5 -1612.5 2143.75 -1612.5 {
lab=#net54}
N 1942.5 -1632.5 1942.5 -1631.25 {
lab=#net53}
N 1942.5 -1632.5 2143.75 -1632.5 {
lab=#net53}
N 1922.5 -1652.5 1922.5 -1651.25 {
lab=#net52}
N 1922.5 -1652.5 2145 -1652.5 {
lab=#net52}
N 1912.5 -1672.5 1912.5 -1671.25 {
lab=#net51}
N 1912.5 -1672.5 2143.75 -1672.5 {
lab=#net51}
N 1892.5 -1692.5 2143.75 -1692.5 {
lab=#net50}
N 1892.5 -1692.5 1892.5 -1691.25 {
lab=#net50}
N 1872.5 -1712.5 2143.75 -1712.5 {
lab=#net49}
N 1872.5 -1712.5 1872.5 -1711.25 {
lab=#net49}
N 1862.5 -1732.5 2143.75 -1732.5 {
lab=#net64}
N 1862.5 -1741.25 1862.5 -1732.5 {
lab=#net64}
N 1882.5 -1752.5 2143.75 -1752.5 {
lab=#net63}
N 1882.5 -1841.25 1882.5 -1752.5 {
lab=#net63}
N 1902.5 -1772.5 2143.75 -1772.5 {
lab=#net62}
N 1902.5 -1942.5 1902.5 -1772.5 {
lab=#net62}
N 1922.5 -2041.25 1922.5 -1792.5 {
lab=#net61}
N 1922.5 -1792.5 2143.75 -1792.5 {
lab=#net61}
N 1942.5 -2141.25 1942.5 -1812.5 {
lab=#net60}
N 1942.5 -1812.5 2143.75 -1812.5 {
lab=#net60}
N 1963.75 -2241.25 1963.75 -1832.5 {
lab=#net59}
N 1963.75 -1832.5 2146.25 -1832.5 {
lab=#net59}
N 813.75 -1001.25 815 -1001.25 {
lab=#net3}
N 813.125 -2201.25 816.25 -2201.25 {
lab=#net15}
N 813.75 -2001.25 815.625 -2001.25 {
lab=#net13}
N 813.75 -1801.25 815 -1801.25 {
lab=#net11}
N 813.75 -1601.25 815.625 -1601.25 {
lab=#net9}
N 813.75 -1401.25 815.625 -1401.25 {
lab=#net7}
N 813.75 -1201.25 815 -1201.25 {
lab=#net5}
C {devices/gnd.sym} 1153.75 -741.25 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 1153.75 -841.25 0 0 {name=l3 lab=GND}
C {devices/gnd.sym} 1153.75 -941.25 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} 1153.75 -1041.25 0 0 {name=l5 lab=GND}
C {devices/gnd.sym} 1153.75 -1141.25 0 0 {name=l6 lab=GND}
C {devices/gnd.sym} 1153.75 -1241.25 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 1153.75 -1341.25 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} 1153.75 -1441.25 0 0 {name=l9 lab=GND}
C {devices/gnd.sym} 1153.75 -1541.25 0 0 {name=l10 lab=GND}
C {devices/gnd.sym} 1153.75 -1641.25 0 0 {name=l11 lab=GND}
C {devices/gnd.sym} 1153.75 -1741.25 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 1153.75 -1841.25 0 0 {name=l13 lab=GND}
C {devices/gnd.sym} 1153.75 -1941.25 0 0 {name=l14 lab=GND}
C {devices/gnd.sym} 1153.75 -2041.25 0 0 {name=l15 lab=GND}
C {devices/gnd.sym} 1153.75 -2141.25 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} 1153.75 -2241.25 0 0 {name=l17 lab=GND}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -751.25 0 0 {name=R1
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -851.25 0 0 {name=R2
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -951.25 0 0 {name=R3
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1051.25 0 0 {name=R4
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1151.25 0 0 {name=R5
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1251.25 0 0 {name=R6
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1351.25 0 0 {name=R7
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1451.25 0 0 {name=R8
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1551.25 0 0 {name=R9
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1651.25 0 0 {name=R10
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1751.25 0 0 {name=R11
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1851.25 0 0 {name=R12
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -1951.25 0 0 {name=R13
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2051.25 0 0 {name=R14
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2151.25 0 0 {name=R15
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2251.25 0 0 {name=R16
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 593.75 -2351.25 0 0 {name=R18
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {devices/code.sym} 1253.75 -441.25 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/gnd.sym} 1603.75 -1221.25 0 0 {name=l20 lab=GND}
C {devices/gnd.sym} 1603.75 -1121.25 0 0 {name=l21 lab=GND}
C {devices/gnd.sym} 1603.75 -1021.25 0 0 {name=l22 lab=GND}
C {devices/gnd.sym} 1603.75 -921.25 0 0 {name=l23 lab=GND}
C {devices/gnd.sym} 1603.75 -821.25 0 0 {name=l24 lab=GND}
C {devices/gnd.sym} 1603.75 -721.25 0 0 {name=l25 lab=GND}
C {devices/gnd.sym} 1603.75 -1321.25 0 0 {name=l26 lab=GND}
C {devices/gnd.sym} 1603.75 -1421.25 0 0 {name=l27 lab=GND}
C {devices/gnd.sym} 1603.75 -1521.25 0 0 {name=l28 lab=GND}
C {devices/gnd.sym} 1603.75 -1621.25 0 0 {name=l29 lab=GND}
C {devices/gnd.sym} 1603.75 -1721.25 0 0 {name=l30 lab=GND}
C {devices/gnd.sym} 1603.75 -1821.25 0 0 {name=l31 lab=GND}
C {devices/gnd.sym} 1603.75 -1921.25 0 0 {name=l32 lab=GND}
C {devices/gnd.sym} 1603.75 -2021.25 0 0 {name=l33 lab=GND}
C {devices/gnd.sym} 1603.75 -2121.25 0 0 {name=l38 lab=GND}
C {devices/gnd.sym} 1603.75 -2221.25 0 0 {name=l39 lab=GND}
C {devices/noconn.sym} 1603.75 -741.25 2 0 {name=l57}
C {devices/noconn.sym} 1603.75 -841.25 2 0 {name=l58}
C {devices/noconn.sym} 1603.75 -941.25 2 0 {name=l59}
C {devices/noconn.sym} 1603.75 -1041.25 2 0 {name=l60}
C {devices/noconn.sym} 1603.75 -1141.25 2 0 {name=l61}
C {devices/noconn.sym} 1603.75 -1241.25 2 0 {name=l62}
C {devices/noconn.sym} 1603.75 -1341.25 2 0 {name=l63}
C {devices/noconn.sym} 1603.75 -1441.25 2 0 {name=l64}
C {devices/noconn.sym} 1603.75 -1541.25 2 0 {name=l65}
C {devices/noconn.sym} 1603.75 -1641.25 2 0 {name=l66}
C {devices/noconn.sym} 1603.75 -1741.25 2 0 {name=l67}
C {devices/noconn.sym} 1603.75 -1841.25 2 0 {name=l68}
C {devices/noconn.sym} 1603.75 -1941.25 2 0 {name=l69}
C {devices/noconn.sym} 1603.75 -2041.25 2 0 {name=l70}
C {devices/noconn.sym} 1603.75 -2141.25 2 0 {name=l71}
C {devices/noconn.sym} 1603.75 -2241.25 2 0 {name=l72}
C {sky130_stdcells/buf_1.sym} 1263.75 -2281.25 0 0 {name=x64 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2261.25 0 0 {name=x34 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2181.25 0 0 {name=x35 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2161.25 0 0 {name=x36 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2081.25 0 0 {name=x37 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -2061.25 0 0 {name=x38 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1981.25 0 0 {name=x39 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1961.25 0 0 {name=x40 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1881.25 0 0 {name=x41 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1861.25 0 0 {name=x42 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1781.25 0 0 {name=x43 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1761.25 0 0 {name=x44 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1681.25 0 0 {name=x45 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1661.25 0 0 {name=x46 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1581.25 0 0 {name=x47 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1561.25 0 0 {name=x48 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1481.25 0 0 {name=x49 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1461.25 0 0 {name=x50 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1381.25 0 0 {name=x51 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1361.25 0 0 {name=x52 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1281.25 0 0 {name=x53 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1261.25 0 0 {name=x54 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1181.25 0 0 {name=x55 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1161.25 0 0 {name=x56 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1081.25 0 0 {name=x57 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -1061.25 0 0 {name=x58 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -981.25 0 0 {name=x59 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -961.25 0 0 {name=x60 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -881.25 0 0 {name=x61 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -861.25 0 0 {name=x62 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -781.25 0 0 {name=x63 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1263.75 -761.25 0 0 {name=x65 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -2251.25 0 0 {name=x19}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -2151.25 0 0 {name=x20}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -2051.25 0 0 {name=x21}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1951.25 0 0 {name=x22}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1851.25 0 0 {name=x23}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1751.25 0 0 {name=x24}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1651.25 0 0 {name=x25}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1551.25 0 0 {name=x26}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1451.25 0 0 {name=x27}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1351.25 0 0 {name=x28}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1251.25 0 0 {name=x29}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1151.25 0 0 {name=x30}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -1051.25 0 0 {name=x31}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -951.25 0 0 {name=x32}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -851.25 0 0 {name=x33}
C {/foss/designs/Analog_FA23_SP24/RSlatch/xschem/RSfetsym.sym} 1453.75 -751.25 0 0 {name=x66}
C {/foss/designs/Analog_FA23_SP24/PriorityEncoder/xschem/16to4_PriorityEncoder_v0p0p1.sym} 2292.5 -1712.5 0 0 {name=x1}
C {devices/gnd.sym} 2142.5 -1872.5 1 0 {name=l40 lab=GND}
C {devices/opin.sym} 2442.5 -1892.5 0 0 {name=p173 lab=OUT3}
C {devices/opin.sym} 2442.5 -1872.5 0 0 {name=p158 lab=OUT2}
C {devices/opin.sym} 2442.5 -1852.5 0 0 {name=p159 lab=OUT1}
C {devices/opin.sym} 2442.5 -1832.5 0 0 {name=p160 lab=OUT0}
C {devices/ipin.sym} 50 -1445 2 0 {name=p162 lab=VDD}
C {devices/ipin.sym} 50 -1285 2 0 {name=p174 lab=GND}
C {devices/vdd.sym} 50 -1445 0 0 {name=l41 lab=VDD}
C {devices/gnd.sym} 50 -1285 0 1 {name=l42 lab=GND}
C {devices/ipin.sym} 200 -1440 2 0 {name=p116 lab=VIN}
C {devices/vdd.sym} 200 -1440 0 0 {name=l18 lab=VIN}
C {devices/ipin.sym} 207.5 -1285 2 0 {name=p118 lab=CLK}
C {devices/vdd.sym} 207.5 -1285 0 0 {name=l44 lab=CLK}
C {devices/ipin.sym} 593.75 -2420 1 0 {name=p1 lab=VFS}
C {devices/ipin.sym} 593.75 -681.25 3 0 {name=p98 lab=VL}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -2271.25 0 0 {name=x2}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 965 -2171.25 0 0 {name=x3}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -2071.25 0 0 {name=x4}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 965 -1971.25 0 0 {name=x5}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -1871.25 0 0 {name=x6}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 965 -1771.25 0 0 {name=x7}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -1671.25 0 0 {name=x8}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 965 -1571.25 0 0 {name=x9}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -1471.25 0 0 {name=x10}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 965 -1371.25 0 0 {name=x11}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -1271.25 0 0 {name=x12}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 965 -1171.25 0 0 {name=x13}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -1071.25 0 0 {name=x14}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 965 -971.25 0 0 {name=x15}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -871.25 0 0 {name=x16}
C {/foss/designs/Analog_FA23_SP24/strongARM/class_AB_v4_sym.sym} 963.75 -771.25 0 0 {name=x17}
C {/foss/designs/Analog_FA23_SP24/PTAT/xschem/PTAT_v0p0p0.sym} 640 -2500 0 0 {name=x18}
C {devices/vdd.sym} 773.75 -2281.25 3 0 {name=l2 lab=VIN}
C {devices/vdd.sym} 773.75 -2261.25 3 0 {name=l19 lab=IB}
C {devices/vdd.sym} 773.75 -2241.25 3 0 {name=l34 lab=CLK}
C {devices/vdd.sym} 776.25 -2181.25 3 0 {name=l35 lab=VIN}
C {devices/vdd.sym} 776.25 -2161.25 3 0 {name=l36 lab=IB}
C {devices/vdd.sym} 776.25 -2141.25 3 0 {name=l37 lab=CLK}
C {devices/vdd.sym} 773.75 -2081.25 3 0 {name=l45 lab=VIN}
C {devices/vdd.sym} 773.75 -2061.25 3 0 {name=l46 lab=IB}
C {devices/vdd.sym} 773.75 -2041.25 3 0 {name=l47 lab=CLK}
C {devices/vdd.sym} 775 -1981.25 3 0 {name=l48 lab=VIN}
C {devices/vdd.sym} 775 -1961.25 3 0 {name=l49 lab=IB}
C {devices/vdd.sym} 775 -1941.25 3 0 {name=l50 lab=CLK}
C {devices/vdd.sym} 773.75 -1881.25 3 0 {name=l51 lab=VIN}
C {devices/vdd.sym} 773.75 -1861.25 3 0 {name=l52 lab=IB}
C {devices/vdd.sym} 773.75 -1841.25 3 0 {name=l53 lab=CLK}
C {devices/vdd.sym} 775 -1781.25 3 0 {name=l54 lab=VIN}
C {devices/vdd.sym} 775 -1761.25 3 0 {name=l55 lab=IB}
C {devices/vdd.sym} 775 -1741.25 3 0 {name=l56 lab=CLK}
C {devices/vdd.sym} 773.75 -1681.25 3 0 {name=l73 lab=VIN}
C {devices/vdd.sym} 773.75 -1661.25 3 0 {name=l74 lab=IB}
C {devices/vdd.sym} 773.75 -1641.25 3 0 {name=l75 lab=CLK}
C {devices/vdd.sym} 775 -1581.25 3 0 {name=l76 lab=VIN}
C {devices/vdd.sym} 775 -1561.25 3 0 {name=l77 lab=IB}
C {devices/vdd.sym} 775 -1541.25 3 0 {name=l78 lab=CLK}
C {devices/vdd.sym} 775 -1481.25 3 0 {name=l79 lab=VIN}
C {devices/vdd.sym} 775 -1461.25 3 0 {name=l80 lab=IB}
C {devices/vdd.sym} 775 -1441.25 3 0 {name=l81 lab=CLK}
C {devices/vdd.sym} 776.25 -1381.25 3 0 {name=l82 lab=VIN}
C {devices/vdd.sym} 776.25 -1361.25 3 0 {name=l83 lab=IB}
C {devices/vdd.sym} 776.25 -1341.25 3 0 {name=l84 lab=CLK}
C {devices/vdd.sym} 775 -1281.25 3 0 {name=l85 lab=VIN}
C {devices/vdd.sym} 775 -1261.25 3 0 {name=l86 lab=IB}
C {devices/vdd.sym} 775 -1241.25 3 0 {name=l87 lab=CLK}
C {devices/vdd.sym} 776.25 -1181.25 3 0 {name=l88 lab=VIN}
C {devices/vdd.sym} 776.25 -1161.25 3 0 {name=l89 lab=IB}
C {devices/vdd.sym} 776.25 -1141.25 3 0 {name=l90 lab=CLK}
C {devices/vdd.sym} 775 -1081.25 3 0 {name=l91 lab=VIN}
C {devices/vdd.sym} 775 -1061.25 3 0 {name=l92 lab=IB}
C {devices/vdd.sym} 775 -1041.25 3 0 {name=l93 lab=CLK}
C {devices/vdd.sym} 776.25 -981.25 3 0 {name=l94 lab=VIN}
C {devices/vdd.sym} 776.25 -961.25 3 0 {name=l95 lab=IB}
C {devices/vdd.sym} 776.25 -941.25 3 0 {name=l96 lab=CLK}
C {devices/vdd.sym} 775 -881.25 3 0 {name=l97 lab=VIN}
C {devices/vdd.sym} 775 -861.25 3 0 {name=l98 lab=IB}
C {devices/vdd.sym} 775 -841.25 3 0 {name=l99 lab=CLK}
C {devices/vdd.sym} 775 -781.25 3 0 {name=l100 lab=VIN}
C {devices/vdd.sym} 775 -761.25 3 0 {name=l101 lab=IB}
C {devices/vdd.sym} 775 -741.25 3 0 {name=l102 lab=CLK}
C {devices/vdd.sym} 1153.75 -2301.25 1 0 {name=l103 lab=VDD}
C {devices/vdd.sym} 1153.75 -2201.25 1 0 {name=l104 lab=VDD}
C {devices/vdd.sym} 1153.75 -2101.25 1 0 {name=l105 lab=VDD}
C {devices/vdd.sym} 1153.75 -2001.25 1 0 {name=l106 lab=VDD}
C {devices/vdd.sym} 1153.75 -1901.25 1 0 {name=l107 lab=VDD}
C {devices/vdd.sym} 1153.75 -1801.25 1 0 {name=l108 lab=VDD}
C {devices/vdd.sym} 1153.75 -1701.25 1 0 {name=l109 lab=VDD}
C {devices/vdd.sym} 1153.75 -1601.25 1 0 {name=l110 lab=VDD}
C {devices/vdd.sym} 1153.75 -1501.25 1 0 {name=l111 lab=VDD}
C {devices/vdd.sym} 1153.75 -1401.25 1 0 {name=l112 lab=VDD}
C {devices/vdd.sym} 1152.5 -1301.25 1 0 {name=l113 lab=VDD}
C {devices/vdd.sym} 1152.5 -1201.25 1 0 {name=l114 lab=VDD}
C {devices/vdd.sym} 1151.25 -1101.25 1 0 {name=l115 lab=VDD}
C {devices/vdd.sym} 1151.25 -1001.25 1 0 {name=l116 lab=VDD}
C {devices/vdd.sym} 1152.5 -901.25 1 0 {name=l117 lab=VDD}
C {devices/vdd.sym} 1152.5 -801.25 1 0 {name=l118 lab=VDD}
C {devices/vdd.sym} 1603.75 -2281.25 1 0 {name=l119 lab=VDD}
C {devices/vdd.sym} 1603.75 -2181.25 1 0 {name=l120 lab=VDD}
C {devices/vdd.sym} 1603.75 -2081.25 1 0 {name=l121 lab=VDD}
C {devices/vdd.sym} 1603.75 -1981.25 1 0 {name=l122 lab=VDD}
C {devices/vdd.sym} 1603.75 -1881.25 1 0 {name=l123 lab=VDD}
C {devices/vdd.sym} 1603.75 -1781.25 1 0 {name=l124 lab=VDD}
C {devices/vdd.sym} 1603.75 -1681.25 1 0 {name=l125 lab=VDD}
C {devices/vdd.sym} 1603.75 -1581.25 1 0 {name=l126 lab=VDD}
C {devices/vdd.sym} 1603.75 -1481.25 1 0 {name=l127 lab=VDD}
C {devices/vdd.sym} 1603.75 -1381.25 1 0 {name=l128 lab=VDD}
C {devices/vdd.sym} 1603.75 -1281.25 1 0 {name=l129 lab=VDD}
C {devices/vdd.sym} 1603.75 -1181.25 1 0 {name=l130 lab=VDD}
C {devices/vdd.sym} 1603.75 -1081.25 1 0 {name=l131 lab=VDD}
C {devices/vdd.sym} 1603.75 -981.25 1 0 {name=l132 lab=VDD}
C {devices/vdd.sym} 1603.75 -881.25 1 0 {name=l133 lab=VDD}
C {devices/vdd.sym} 1603.75 -781.25 1 0 {name=l134 lab=VDD}
C {devices/vdd.sym} 2142.5 -1892.5 3 0 {name=l135 lab=VDD}
C {devices/vdd.sym} 2142.5 -1852.5 3 0 {name=l136 lab=VDD}
C {devices/vdd.sym} 790 -2510 1 0 {name=l137 lab=IB}
C {devices/vdd.sym} 490 -2510 3 0 {name=l43 lab=VDD}
C {devices/gnd.sym} 490 -2490 1 0 {name=l138 lab=GND}
