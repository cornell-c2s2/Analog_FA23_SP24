v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 3025 -2178.75 3825 -1778.75 {flags=graph
y1=-0.36
y2=1.44
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 3025 -2578.75 3825 -2178.75 {flags=graph
y1=-0.06
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y1
v1
vin
a1
q1"}
B 2 3025 -2978.75 3825 -2578.75 {flags=graph
y1=-0.058
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 5 6 8 21"
node="y2
v2
vin
a2
q2"}
B 2 3025 -3378.75 3825 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y3
v3
vin
a3
q3"}
B 2 3025 -3778.75 3825 -3378.75 {flags=graph
y1=1.5084
y2=3.4664
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y4
v4
vin
a4
q4"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 3825 -2578.75 4625 -2178.75 {flags=graph
y1=-0.056
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6 8 21"
node="y5
v5
vin
a5
q5"}
B 2 3825 -2978.75 4625 -2578.75 {flags=graph
y1=-0.055
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y6
v6
vin
a6
q6"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 3825 -3378.75 4625 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y7
v7
vin
a7
q7"}
B 2 3825 -3778.75 4625 -3378.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y8
v8
vin
a8
q8"}
B 2 4625 -2578.75 5425 -2178.75 {flags=graph
y1=-0.06
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y9
v9
vin
a9
q9"}
B 2 4625 -2978.75 5425 -2578.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 5 6 8 21"
node="y10
v10
vin
a10
q10"}
B 2 4625 -3378.75 5425 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y11
v11
vin
a11
q11"}
B 2 4625 -3778.75 5425 -3378.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y12
v12
vin
a12
q12"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 5425 -2578.75 6225 -2178.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6 8 21"
node="y13
v13
vin
a13
q13"}
B 2 5425 -2978.75 6225 -2578.75 {flags=graph
y1=-0.056
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y14
v14
vin
a14
q14"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 5425 -3378.75 6225 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y15
v15
vin
a15
q15"}
B 2 5425 -3778.75 6225 -3378.75 {flags=graph
y1=-0.062
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y16
v16
vin
a16
q16"}
B 2 3825 -2178.75 4625 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 4625 -2178.75 5425 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 5425 -2178.75 6225 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 3040 -1686.25 3840 -1286.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=7
node=out3}
B 2 3040 -1286.25 3840 -886.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=21
node=out2}
B 2 3840 -1686.25 4640 -1286.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=8
node=out1}
B 2 3840 -1286.25 4640 -886.25 {flags=graph
y1=-0.0058
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=12
node=out0}
B 2 3840 -886.25 4638.75 -443.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk
hilight_wave=0}
B 2 3041.25 -886.25 3840 -443.75 {flags=graph
y1=0.49
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


hilight_wave=0
color=10
node=vin}
B 2 5111.25 -1463.75 5911.25 -1063.75 {flags=graph
y1=-0.056
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6"
node="y5
q5
out0"}
B 2 2765 -4440 3565 -4040 {flags=graph
y1=0.58
y2=0.61
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=5
node=ib}
N 1320 -1883.75 1320 -1843.75 {
lab=CLK}
N 1320 -1783.75 1320 -1743.75 {
lab=GND}
N 1160 -1583.75 1190 -1583.75 {
lab=VDD}
N 1160 -1523.75 1160 -1483.75 {
lab=GND}
N 1320 -1623.75 1320 -1583.75 {
lab=VFS}
N 1320 -1523.75 1320 -1483.75 {
lab=GND}
N 1492.5 -1512.5 1492.5 -1492.5 {
lab=GND}
N 940 -1883.75 940 -1843.75 {
lab=#net1}
N 940 -1783.75 940 -1743.75 {
lab=GND}
N 940 -1983.75 940 -1943.75 {
lab=VIN}
N 1030 -1505 1030 -1475 {
lab=GND}
N 1383.75 -2821.25 1383.75 -2801.25 {
lab=#net2}
N 1383.75 -2721.25 1383.75 -2701.25 {
lab=#net3}
N 1383.75 -2621.25 1383.75 -2601.25 {
lab=VL}
N 1383.75 -2921.25 1383.75 -2901.25 {
lab=#net4}
N 1383.75 -3021.25 1383.75 -3001.25 {
lab=#net5}
N 1383.75 -3121.25 1383.75 -3101.25 {
lab=#net6}
N 1383.75 -3221.25 1383.75 -3201.25 {
lab=#net7}
N 1383.75 -3321.25 1383.75 -3301.25 {
lab=#net8}
N 1383.75 -3421.25 1383.75 -3401.25 {
lab=#net9}
N 1383.75 -3521.25 1383.75 -3501.25 {
lab=#net10}
N 1383.75 -3621.25 1383.75 -3601.25 {
lab=#net11}
N 1383.75 -3721.25 1383.75 -3701.25 {
lab=#net12}
N 1383.75 -3821.25 1383.75 -3801.25 {
lab=#net13}
N 1383.75 -3921.25 1383.75 -3901.25 {
lab=#net14}
N 1383.75 -4021.25 1383.75 -4001.25 {
lab=#net15}
N 1383.75 -4121.25 1383.75 -4101.25 {
lab=#net16}
N 1383.75 -4221.25 1383.75 -4201.25 {
lab=#net17}
N 1323.75 -4171.25 1363.75 -4171.25 {
lab=VL}
N 1323.75 -4171.25 1323.75 -4071.25 {
lab=VL}
N 1323.75 -4071.25 1363.75 -4071.25 {
lab=VL}
N 1323.75 -3971.25 1363.75 -3971.25 {
lab=VL}
N 1323.75 -3871.25 1363.75 -3871.25 {
lab=VL}
N 1323.75 -3771.25 1363.75 -3771.25 {
lab=VL}
N 1323.75 -3671.25 1363.75 -3671.25 {
lab=VL}
N 1323.75 -3571.25 1363.75 -3571.25 {
lab=VL}
N 1323.75 -3471.25 1363.75 -3471.25 {
lab=VL}
N 1323.75 -3371.25 1363.75 -3371.25 {
lab=VL}
N 1323.75 -3271.25 1363.75 -3271.25 {
lab=VL}
N 1323.75 -3171.25 1363.75 -3171.25 {
lab=VL}
N 1323.75 -3071.25 1363.75 -3071.25 {
lab=VL}
N 1323.75 -2971.25 1363.75 -2971.25 {
lab=VL}
N 1323.75 -2871.25 1363.75 -2871.25 {
lab=VL}
N 1323.75 -2771.25 1363.75 -2771.25 {
lab=VL}
N 1323.75 -2671.25 1363.75 -2671.25 {
lab=VL}
N 1323.75 -2621.25 1383.75 -2621.25 {
lab=VL}
N 1323.75 -2671.25 1323.75 -2621.25 {
lab=VL}
N 1323.75 -2871.25 1323.75 -2771.25 {
lab=VL}
N 1323.75 -2971.25 1323.75 -2871.25 {
lab=VL}
N 1383.75 -2721.25 1603.75 -2721.25 {
lab=#net3}
N 1383.75 -4341.25 1383.75 -4301.25 {
lab=VFS}
N 1323.75 -4271.25 1363.75 -4271.25 {
lab=VL}
N 1323.75 -4271.25 1323.75 -4171.25 {
lab=VL}
N 1383.75 -2821.25 1620 -2821.25 {
lab=#net2}
N 1383.75 -2921.25 1631.25 -2921.25 {
lab=#net4}
N 1383.75 -3021.25 1642.5 -3021.25 {
lab=#net5}
N 1383.75 -3121.25 1651.25 -3121.25 {
lab=#net6}
N 1383.75 -3221.25 1661.25 -3221.25 {
lab=#net7}
N 1383.75 -3321.25 1646.25 -3321.25 {
lab=#net8}
N 1383.75 -3421.25 1603.75 -3421.25 {
lab=#net9}
N 1383.75 -3521.25 1722.5 -3521.25 {
lab=#net10}
N 1383.75 -3621.25 1603.75 -3621.25 {
lab=#net11}
N 1383.75 -3721.25 1603.75 -3721.25 {
lab=#net12}
N 1383.75 -3821.25 1607.5 -3821.25 {
lab=#net13}
N 1383.75 -3921.25 1628.75 -3921.25 {
lab=#net14}
N 1383.75 -4021.25 1625 -4021.25 {
lab=#net15}
N 1383.75 -4121.25 1611.25 -4121.25 {
lab=#net16}
N 1383.75 -4221.25 1603.75 -4221.25 {
lab=#net17}
N 1323.75 -4071.25 1323.75 -3971.25 {
lab=VL}
N 1323.75 -3971.25 1323.75 -3871.25 {
lab=VL}
N 1323.75 -3871.25 1323.75 -3771.25 {
lab=VL}
N 1323.75 -3771.25 1323.75 -3671.25 {
lab=VL}
N 1323.75 -3671.25 1323.75 -3571.25 {
lab=VL}
N 1323.75 -3571.25 1323.75 -3471.25 {
lab=VL}
N 1323.75 -3471.25 1323.75 -3371.25 {
lab=VL}
N 1323.75 -3371.25 1323.75 -3271.25 {
lab=VL}
N 1323.75 -3271.25 1323.75 -3171.25 {
lab=VL}
N 1323.75 -3171.25 1323.75 -3071.25 {
lab=VL}
N 1323.75 -3071.25 1323.75 -2971.25 {
lab=VL}
N 1323.75 -2771.25 1323.75 -2671.25 {
lab=VL}
N 1383.75 -2641.25 1383.75 -2621.25 {
lab=VL}
N 1383.75 -2741.25 1383.75 -2721.25 {
lab=#net3}
N 1383.75 -2841.25 1383.75 -2821.25 {
lab=#net2}
N 1383.75 -2941.25 1383.75 -2921.25 {
lab=#net4}
N 1383.75 -3041.25 1383.75 -3021.25 {
lab=#net5}
N 1383.75 -3141.25 1383.75 -3121.25 {
lab=#net6}
N 1383.75 -3241.25 1383.75 -3221.25 {
lab=#net7}
N 1383.75 -3341.25 1383.75 -3321.25 {
lab=#net8}
N 1383.75 -3441.25 1383.75 -3421.25 {
lab=#net9}
N 1383.75 -3541.25 1383.75 -3521.25 {
lab=#net10}
N 1383.75 -3641.25 1383.75 -3621.25 {
lab=#net11}
N 1383.75 -3741.25 1383.75 -3721.25 {
lab=#net12}
N 1383.75 -3841.25 1383.75 -3821.25 {
lab=#net13}
N 1383.75 -3941.25 1383.75 -3921.25 {
lab=#net14}
N 1383.75 -4041.25 1383.75 -4021.25 {
lab=#net15}
N 1383.75 -4141.25 1383.75 -4121.25 {
lab=#net16}
N 1383.75 -4241.25 1383.75 -4221.25 {
lab=#net17}
N 1603.75 -4425 1737.5 -4425 {
lab=#net17}
N 1603.75 -4425 1603.75 -4221.25 {
lab=#net17}
N 1611.25 -4295 1611.25 -4121.25 {
lab=#net16}
N 1611.25 -4295 1737.5 -4295 {
lab=#net16}
N 1625 -4165 1625 -4021.25 {
lab=#net15}
N 1625 -4165 1738.75 -4165 {
lab=#net15}
N 1628.75 -4035 1628.75 -3921.25 {
lab=#net14}
N 1628.75 -4035 1737.5 -4035 {
lab=#net14}
N 1607.5 -3905 1737.5 -3905 {
lab=#net13}
N 1607.5 -3905 1607.5 -3821.25 {
lab=#net13}
N 1603.75 -3775 1737.5 -3775 {
lab=#net12}
N 1603.75 -3775 1603.75 -3721.25 {
lab=#net12}
N 1603.75 -3645 1737.5 -3645 {
lab=#net11}
N 1603.75 -3645 1603.75 -3621.25 {
lab=#net11}
N 1722.5 -3521.25 1722.5 -3515 {
lab=#net10}
N 1722.5 -3515 1737.5 -3515 {
lab=#net10}
N 1603.75 -3421.25 1603.75 -3385 {
lab=#net9}
N 1603.75 -3385 1737.5 -3385 {
lab=#net9}
N 1646.25 -3321.25 1646.25 -3255 {
lab=#net8}
N 1646.25 -3255 1737.5 -3255 {
lab=#net8}
N 1661.25 -3221.25 1661.25 -3125 {
lab=#net7}
N 1661.25 -3125 1737.5 -3125 {
lab=#net7}
N 1651.25 -3121.25 1651.25 -2995 {
lab=#net6}
N 1651.25 -2995 1737.5 -2995 {
lab=#net6}
N 1642.5 -3021.25 1642.5 -2865 {
lab=#net5}
N 1642.5 -2865 1737.5 -2865 {
lab=#net5}
N 1631.25 -2921.25 1631.25 -2735 {
lab=#net4}
N 1631.25 -2735 1737.5 -2735 {
lab=#net4}
N 1620 -2821.25 1620 -2605 {
lab=#net2}
N 1620 -2605 1737.5 -2605 {
lab=#net2}
N 1603.75 -2721.25 1603.75 -2475 {
lab=#net3}
N 1603.75 -2475 1738.75 -2475 {
lab=#net3}
N 2035 -4465 2290 -4465 {
lab=#net18}
N 2290 -4465 2290 -3587.5 {
lab=#net18}
N 2290 -3587.5 2440 -3587.5 {
lab=#net18}
N 2037.5 -4335 2277.5 -4335 {
lab=#net19}
N 2277.5 -4335 2277.5 -3567.5 {
lab=#net19}
N 2277.5 -3567.5 2440 -3567.5 {
lab=#net19}
N 2037.5 -4205 2265 -4205 {
lab=#net20}
N 2265 -4205 2265 -3547.5 {
lab=#net20}
N 2265 -3547.5 2440 -3547.5 {
lab=#net20}
N 2037.5 -4075 2247.5 -4075 {
lab=#net21}
N 2247.5 -4075 2247.5 -3527.5 {
lab=#net21}
N 2247.5 -3527.5 2440 -3527.5 {
lab=#net21}
N 2037.5 -3945 2237.5 -3945 {
lab=#net22}
N 2237.5 -3945 2237.5 -3507.5 {
lab=#net22}
N 2237.5 -3507.5 2440 -3507.5 {
lab=#net22}
N 2037.5 -3815 2222.5 -3815 {
lab=#net23}
N 2222.5 -3815 2222.5 -3487.5 {
lab=#net23}
N 2222.5 -3487.5 2440 -3487.5 {
lab=#net23}
N 2037.5 -3685 2215 -3685 {
lab=#net24}
N 2215 -3685 2215 -3467.5 {
lab=#net24}
N 2215 -3467.5 2440 -3467.5 {
lab=#net24}
N 2037.5 -3555 2200 -3555 {
lab=#net25}
N 2200 -3555 2200 -3447.5 {
lab=#net25}
N 2200 -3447.5 2440 -3447.5 {
lab=#net25}
N 2037.5 -3425 2422.5 -3425 {
lab=#net26}
N 2422.5 -3427.5 2422.5 -3425 {
lab=#net26}
N 2422.5 -3427.5 2440 -3427.5 {
lab=#net26}
N 2037.5 -3295 2067.5 -3295 {
lab=#net27}
N 2067.5 -3407.5 2067.5 -3295 {
lab=#net27}
N 2067.5 -3407.5 2440 -3407.5 {
lab=#net27}
N 2037.5 -3165 2085 -3165 {
lab=#net28}
N 2085 -3387.5 2085 -3165 {
lab=#net28}
N 2085 -3387.5 2440 -3387.5 {
lab=#net28}
N 2037.5 -3035 2120 -3035 {
lab=#net29}
N 2120 -3367.5 2120 -3035 {
lab=#net29}
N 2120 -3367.5 2440 -3367.5 {
lab=#net29}
N 2037.5 -2905 2152.5 -2905 {
lab=#net30}
N 2152.5 -3347.5 2152.5 -2905 {
lab=#net30}
N 2152.5 -3347.5 2440 -3347.5 {
lab=#net30}
N 2037.5 -2775 2197.5 -2775 {
lab=#net31}
N 2197.5 -3327.5 2197.5 -2775 {
lab=#net31}
N 2197.5 -3327.5 2440 -3327.5 {
lab=#net31}
N 2037.5 -2645 2222.5 -2645 {
lab=#net32}
N 2222.5 -3307.5 2222.5 -2645 {
lab=#net32}
N 2222.5 -3307.5 2440 -3307.5 {
lab=#net32}
N 2037.5 -2515 2262.5 -2515 {
lab=#net33}
N 2262.5 -3287.5 2262.5 -2515 {
lab=#net33}
N 2262.5 -3287.5 2440 -3287.5 {
lab=#net33}
N 1492.5 -1600 1492.5 -1572.5 {
lab=VL}
C {devices/vsource.sym} 1320 -1813.75 0 0 {name=V4 value="pulse(0 1.8 8ns 1ns 1ns 20ns 40ns)" savecurrent=false}
C {devices/gnd.sym} 1320 -1743.75 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 1320 -1883.75 2 0 {name=p197 sig_type=std_logic lab=CLK}
C {devices/vsource.sym} 1160 -1553.75 0 0 {name=V1 value=1.8 savecurrent=false}
C {devices/gnd.sym} 1160 -1483.75 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 1190 -1583.75 2 0 {name=p198 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 1320 -1553.75 0 0 {name=V2 value=1.6 savecurrent=false}
C {devices/gnd.sym} 1320 -1483.75 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} 1320 -1623.75 2 0 {name=p199 sig_type=std_logic lab=VFS}
C {devices/code_shown.sym} 1770 -1683.75 0 0 {name=COMMANDS only_toplevel=false value=
"
.options savecurrents
.control

save all

tran 0.005n 240n
write flashADC_Testing_v0p4p4.raw

.endc
"}
C {devices/vsource.sym} 1492.5 -1542.5 0 0 {name=V5 value=0.6 savecurrent=false}
C {devices/gnd.sym} 1492.5 -1492.5 0 0 {name=l2 lab=GND}
C {devices/vsource.sym} 940 -1813.75 0 0 {name=V7 value="PWL(0ns 0.5 230ns 1.7)" savecurrent=false}
C {devices/gnd.sym} 940 -1743.75 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} 940 -1983.75 2 0 {name=p133 sig_type=std_logic lab=VIN}
C {devices/res.sym} 940 -1913.75 0 0 {name=R36
value=1k
footprint=1206
device=resistor
m=1}
C {devices/code.sym} 1820 -1903.75 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/vdd.sym} 1160 -1583.75 0 0 {name=l80 lab=VDD}
C {devices/lab_pin.sym} 1030 -1505 1 0 {name=p164 sig_type=std_logic lab=GND}
C {devices/gnd.sym} 1030 -1475 0 0 {name=l81 lab=GND}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -2671.25 0 0 {name=R1
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -2771.25 0 0 {name=R2
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -2871.25 0 0 {name=R3
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -2971.25 0 0 {name=R4
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3071.25 0 0 {name=R5
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3171.25 0 0 {name=R6
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3271.25 0 0 {name=R7
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3371.25 0 0 {name=R8
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3471.25 0 0 {name=R9
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3571.25 0 0 {name=R10
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3671.25 0 0 {name=R11
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3771.25 0 0 {name=R12
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3871.25 0 0 {name=R13
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -3971.25 0 0 {name=R14
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -4071.25 0 0 {name=R15
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -4171.25 0 0 {name=R16
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1383.75 -4271.25 0 0 {name=R18
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {/foss/designs/Analog_FA23_SP24/PriorityEncoder/xschem/16to4_PriorityEncoder_v0p0p1.sym} 2590 -3467.5 0 0 {name=x1}
C {devices/gnd.sym} 2440 -3627.5 2 0 {name=l40 lab=GND}
C {devices/opin.sym} 2740 -3647.5 0 0 {name=p173 lab=OUT3}
C {devices/opin.sym} 2740 -3627.5 0 0 {name=p158 lab=OUT2}
C {devices/opin.sym} 2740 -3607.5 0 0 {name=p159 lab=OUT1}
C {devices/opin.sym} 2740 -3587.5 0 0 {name=p160 lab=OUT0}
C {devices/ipin.sym} 1383.75 -4340 1 0 {name=p1 lab=VFS}
C {/foss/designs/Analog_FA23_SP24/PTAT/xschem/PTAT_v0p0p0.sym} 1423.75 -4462.5 0 0 {name=x18}
C {devices/vdd.sym} 2440 -3647.5 3 0 {name=l135 lab=VDD}
C {devices/vdd.sym} 2440 -3607.5 3 0 {name=l136 lab=VDD}
C {devices/vdd.sym} 1273.75 -4472.5 3 0 {name=l43 lab=VDD}
C {devices/gnd.sym} 1273.75 -4452.5 1 0 {name=l138 lab=GND}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -4285 0 0 {name=x2}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -4155 0 0 {name=x3}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -4025 0 0 {name=x4}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3895 0 0 {name=x5}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3765 0 0 {name=x6}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3635 0 0 {name=x7}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3505 0 0 {name=x8}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3375 0 0 {name=x9}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3245 0 0 {name=x10}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -3115 0 0 {name=x11}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2985 0 0 {name=x12}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2855 0 0 {name=x13}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2725 0 0 {name=x14}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2595 0 0 {name=x15}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -2465 0 0 {name=x16}
C {devices/vdd.sym} 1737.5 -4365 3 0 {name=l1 lab=IB}
C {devices/vdd.sym} 1737.5 -4465 3 0 {name=l3 lab=VDD}
C {devices/gnd.sym} 1737.5 -4445 2 0 {name=l4 lab=GND}
C {devices/vdd.sym} 1737.5 -4405 3 0 {name=l5 lab=VIN}
C {devices/vdd.sym} 1737.5 -4385 3 0 {name=l6 lab=CLK}
C {devices/vdd.sym} 1737.5 -4235 3 0 {name=l7 lab=IB}
C {devices/vdd.sym} 1737.5 -4335 3 0 {name=l8 lab=VDD}
C {devices/gnd.sym} 1737.5 -4315 2 0 {name=l9 lab=GND}
C {devices/vdd.sym} 1737.5 -4275 3 0 {name=l10 lab=VIN}
C {devices/vdd.sym} 1737.5 -4255 3 0 {name=l11 lab=CLK}
C {devices/vdd.sym} 1737.5 -4105 3 0 {name=l12 lab=IB}
C {devices/vdd.sym} 1737.5 -4205 3 0 {name=l13 lab=VDD}
C {devices/gnd.sym} 1737.5 -4185 2 0 {name=l14 lab=GND}
C {devices/vdd.sym} 1737.5 -4145 3 0 {name=l15 lab=VIN}
C {devices/vdd.sym} 1737.5 -4125 3 0 {name=l16 lab=CLK}
C {devices/vdd.sym} 1737.5 -3975 3 0 {name=l22 lab=IB}
C {devices/vdd.sym} 1737.5 -4075 3 0 {name=l23 lab=VDD}
C {devices/gnd.sym} 1737.5 -4055 2 0 {name=l24 lab=GND}
C {devices/vdd.sym} 1737.5 -4015 3 0 {name=l25 lab=VIN}
C {devices/vdd.sym} 1737.5 -3995 3 0 {name=l26 lab=CLK}
C {devices/vdd.sym} 1737.5 -3845 3 0 {name=l27 lab=IB}
C {devices/vdd.sym} 1737.5 -3945 3 0 {name=l28 lab=VDD}
C {devices/gnd.sym} 1737.5 -3925 2 0 {name=l29 lab=GND}
C {devices/vdd.sym} 1737.5 -3885 3 0 {name=l30 lab=VIN}
C {devices/vdd.sym} 1737.5 -3865 3 0 {name=l31 lab=CLK}
C {devices/vdd.sym} 1737.5 -3715 3 0 {name=l32 lab=IB}
C {devices/vdd.sym} 1737.5 -3815 3 0 {name=l33 lab=VDD}
C {devices/gnd.sym} 1737.5 -3795 2 0 {name=l34 lab=GND}
C {devices/vdd.sym} 1737.5 -3755 3 0 {name=l17 lab=VIN}
C {devices/vdd.sym} 1737.5 -3735 3 0 {name=l18 lab=CLK}
C {devices/vdd.sym} 1737.5 -3585 3 0 {name=l20 lab=IB}
C {devices/vdd.sym} 1737.5 -3685 3 0 {name=l38 lab=VDD}
C {devices/gnd.sym} 1737.5 -3665 2 0 {name=l39 lab=GND}
C {devices/vdd.sym} 1737.5 -3625 3 0 {name=l45 lab=VIN}
C {devices/vdd.sym} 1737.5 -3605 3 0 {name=l46 lab=CLK}
C {devices/vdd.sym} 1737.5 -3455 3 0 {name=l47 lab=IB}
C {devices/vdd.sym} 1737.5 -3555 3 0 {name=l48 lab=VDD}
C {devices/gnd.sym} 1737.5 -3535 2 0 {name=l49 lab=GND}
C {devices/vdd.sym} 1737.5 -3495 3 0 {name=l50 lab=VIN}
C {devices/vdd.sym} 1737.5 -3475 3 0 {name=l51 lab=CLK}
C {devices/vdd.sym} 1737.5 -3325 3 0 {name=l52 lab=IB}
C {devices/vdd.sym} 1737.5 -3425 3 0 {name=l53 lab=VDD}
C {devices/gnd.sym} 1737.5 -3405 2 0 {name=l54 lab=GND}
C {devices/vdd.sym} 1737.5 -3365 3 0 {name=l55 lab=VIN}
C {devices/vdd.sym} 1737.5 -3345 3 0 {name=l56 lab=CLK}
C {devices/vdd.sym} 1737.5 -3195 3 0 {name=l57 lab=IB}
C {devices/vdd.sym} 1737.5 -3295 3 0 {name=l58 lab=VDD}
C {devices/gnd.sym} 1737.5 -3275 2 0 {name=l59 lab=GND}
C {devices/vdd.sym} 1737.5 -3235 3 0 {name=l60 lab=VIN}
C {devices/vdd.sym} 1737.5 -3215 3 0 {name=l61 lab=CLK}
C {devices/vdd.sym} 1737.5 -3065 3 0 {name=l67 lab=IB}
C {devices/vdd.sym} 1737.5 -3165 3 0 {name=l68 lab=VDD}
C {devices/gnd.sym} 1737.5 -3145 2 0 {name=l69 lab=GND}
C {devices/vdd.sym} 1737.5 -3105 3 0 {name=l70 lab=VIN}
C {devices/vdd.sym} 1737.5 -3085 3 0 {name=l71 lab=CLK}
C {devices/vdd.sym} 1737.5 -2935 3 0 {name=l72 lab=IB}
C {devices/vdd.sym} 1737.5 -3035 3 0 {name=l73 lab=VDD}
C {devices/gnd.sym} 1737.5 -3015 2 0 {name=l74 lab=GND}
C {devices/vdd.sym} 1737.5 -2975 3 0 {name=l75 lab=VIN}
C {devices/vdd.sym} 1737.5 -2955 3 0 {name=l76 lab=CLK}
C {devices/vdd.sym} 1737.5 -2805 3 0 {name=l77 lab=IB}
C {devices/vdd.sym} 1737.5 -2905 3 0 {name=l78 lab=VDD}
C {devices/gnd.sym} 1737.5 -2885 2 0 {name=l79 lab=GND}
C {devices/vdd.sym} 1737.5 -2845 3 0 {name=l21 lab=VIN}
C {devices/vdd.sym} 1737.5 -2825 3 0 {name=l41 lab=CLK}
C {devices/vdd.sym} 1737.5 -2675 3 0 {name=l82 lab=IB}
C {devices/vdd.sym} 1737.5 -2775 3 0 {name=l83 lab=VDD}
C {devices/gnd.sym} 1737.5 -2755 2 0 {name=l84 lab=GND}
C {devices/vdd.sym} 1737.5 -2715 3 0 {name=l85 lab=VIN}
C {devices/vdd.sym} 1737.5 -2695 3 0 {name=l86 lab=CLK}
C {devices/vdd.sym} 1737.5 -2545 3 0 {name=l87 lab=IB}
C {devices/vdd.sym} 1737.5 -2645 3 0 {name=l88 lab=VDD}
C {devices/gnd.sym} 1737.5 -2625 2 0 {name=l89 lab=GND}
C {devices/vdd.sym} 1737.5 -2585 3 0 {name=l90 lab=VIN}
C {devices/vdd.sym} 1737.5 -2565 3 0 {name=l91 lab=CLK}
C {devices/vdd.sym} 1737.5 -2415 3 0 {name=l92 lab=IB}
C {devices/vdd.sym} 1737.5 -2515 3 0 {name=l93 lab=VDD}
C {devices/gnd.sym} 1737.5 -2495 2 0 {name=l94 lab=GND}
C {devices/vdd.sym} 1737.5 -2455 3 0 {name=l95 lab=VIN}
C {devices/vdd.sym} 1737.5 -2435 3 0 {name=l96 lab=CLK}
C {devices/lab_pin.sym} 1492.5 -1600 2 0 {name=p2 sig_type=std_logic lab=VL}
C {devices/lab_pin.sym} 1383.75 -2601.25 2 0 {name=p3 sig_type=std_logic lab=VL}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1887.5 -4415 0 0 {name=x17}
