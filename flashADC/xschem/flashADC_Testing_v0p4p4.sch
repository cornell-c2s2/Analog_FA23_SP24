v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 3025 -2178.75 3825 -1778.75 {flags=graph
y1=-0.36
y2=1.44
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 3025 -2578.75 3825 -2178.75 {flags=graph
y1=-0.06
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y1
v1
vin
a1
q1"}
B 2 3025 -2978.75 3825 -2578.75 {flags=graph
y1=-0.058
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 5 6 8 21"
node="y2
v2
vin
a2
q2"}
B 2 3025 -3378.75 3825 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y3
v3
vin
a3
q3"}
B 2 3025 -3778.75 3825 -3378.75 {flags=graph
y1=1.5084
y2=3.4664
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y4
v4
vin
a4
q4"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 3825 -2578.75 4625 -2178.75 {flags=graph
y1=-0.056
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6 8 21"
node="y5
v5
vin
a5
q5"}
B 2 3825 -2978.75 4625 -2578.75 {flags=graph
y1=-0.055
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y6
v6
vin
a6
q6"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 3825 -3378.75 4625 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y7
v7
vin
a7
q7"}
B 2 3825 -3778.75 4625 -3378.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y8
v8
vin
a8
q8"}
B 2 4625 -2578.75 5425 -2178.75 {flags=graph
y1=-0.06
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y9
v9
vin
a9
q9"}
B 2 4625 -2978.75 5425 -2578.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0




color="4 5 6 8 21"
node="y10
v10
vin
a10
q10"}
B 2 4625 -3378.75 5425 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21"
node="y11
v11
vin
a11
q11"}
B 2 4625 -3778.75 5425 -3378.75 {flags=graph
y1=-0.059
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y12
v12
vin
a12
q12"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 5425 -2578.75 6225 -2178.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6 8 21"
node="y13
v13
vin
a13
q13"}
B 2 5425 -2978.75 6225 -2578.75 {flags=graph
y1=-0.056
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="y14
v14
vin
a14
q14"
color="4 5 6 8 21"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 5425 -3378.75 6225 -2978.75 {flags=graph
y1=-0.057
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21 4 21"
node="y15
v15
vin
a15
q15
x2.net6
x2.net27"}
B 2 5425 -3778.75 6225 -3378.75 {flags=graph
y1=-0.062
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color="4 5 6 8 21 4 21"
node="y16
v16
vin
a16
q16
x2.net5
x2.net28"}
B 2 3825 -2178.75 4625 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 4625 -2178.75 5425 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 5425 -2178.75 6225 -1778.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk}
B 2 3040 -1686.25 3840 -1286.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=7
node=out3}
B 2 3040 -1286.25 3840 -886.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=21
node=out2}
B 2 3840 -1686.25 4640 -1286.25 {flags=graph
y1=-0.0054
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=8
node=out1}
B 2 3840 -1286.25 4640 -886.25 {flags=graph
y1=-0.0058
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color=12
node=out0}
B 2 3840 -886.25 4638.75 -443.75 {flags=graph
y1=0
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=4
node=clk
hilight_wave=0}
B 2 3041.25 -886.25 3840 -443.75 {flags=graph
y1=0.49
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0


hilight_wave=0
color=10
node=vin}
B 2 5111.25 -1463.75 5911.25 -1063.75 {flags=graph
y1=0.7264
y2=2.6824
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.28684e-07
x2=1.32144e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0

color="4 5 6"
node="y5
q5
out0"}
B 2 2765 -4440 3565 -4040 {flags=graph
y1=0.58
y2=0.61
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=2.4e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=0
logy=0
color=5
node=ib}
N 1320 -1883.75 1320 -1843.75 {
lab=CLK}
N 1320 -1783.75 1320 -1743.75 {
lab=GND}
N 1160 -1583.75 1190 -1583.75 {
lab=VDD}
N 1160 -1523.75 1160 -1483.75 {
lab=GND}
N 1320 -1623.75 1320 -1583.75 {
lab=VFS}
N 1320 -1523.75 1320 -1483.75 {
lab=GND}
N 1492.5 -1512.5 1492.5 -1492.5 {
lab=GND}
N 940 -1883.75 940 -1843.75 {
lab=#net1}
N 940 -1783.75 940 -1743.75 {
lab=GND}
N 940 -1983.75 940 -1943.75 {
lab=VIN}
N 1030 -1505 1030 -1475 {
lab=GND}
N 1492.5 -1600 1492.5 -1572.5 {
lab=VL}
N 1458.75 -2617.5 1458.75 -2597.5 {
lab=#net2}
N 1458.75 -2517.5 1458.75 -2497.5 {
lab=#net3}
N 1458.75 -2417.5 1458.75 -2397.5 {
lab=VL}
N 1458.75 -2717.5 1458.75 -2697.5 {
lab=#net4}
N 1458.75 -2817.5 1458.75 -2797.5 {
lab=#net5}
N 1458.75 -2917.5 1458.75 -2897.5 {
lab=#net6}
N 1458.75 -3017.5 1458.75 -2997.5 {
lab=#net7}
N 1458.75 -3117.5 1458.75 -3097.5 {
lab=#net8}
N 1458.75 -3217.5 1458.75 -3197.5 {
lab=#net9}
N 1458.75 -3317.5 1458.75 -3297.5 {
lab=#net10}
N 1458.75 -3417.5 1458.75 -3397.5 {
lab=#net11}
N 1458.75 -3517.5 1458.75 -3497.5 {
lab=#net12}
N 1458.75 -3617.5 1458.75 -3597.5 {
lab=#net13}
N 1458.75 -3717.5 1458.75 -3697.5 {
lab=#net14}
N 1458.75 -3817.5 1458.75 -3797.5 {
lab=#net15}
N 1458.75 -3917.5 1458.75 -3897.5 {
lab=#net16}
N 1458.75 -4017.5 1458.75 -3997.5 {
lab=#net17}
N 1398.75 -3967.5 1438.75 -3967.5 {
lab=GND}
N 1398.75 -3967.5 1398.75 -3867.5 {
lab=GND}
N 1398.75 -3867.5 1438.75 -3867.5 {
lab=GND}
N 1398.75 -3767.5 1438.75 -3767.5 {
lab=GND}
N 1398.75 -3667.5 1438.75 -3667.5 {
lab=GND}
N 1398.75 -3567.5 1438.75 -3567.5 {
lab=GND}
N 1398.75 -3467.5 1438.75 -3467.5 {
lab=GND}
N 1398.75 -3367.5 1438.75 -3367.5 {
lab=GND}
N 1398.75 -3267.5 1438.75 -3267.5 {
lab=GND}
N 1398.75 -3167.5 1438.75 -3167.5 {
lab=GND}
N 1398.75 -3067.5 1438.75 -3067.5 {
lab=GND}
N 1398.75 -2967.5 1438.75 -2967.5 {
lab=GND}
N 1398.75 -2867.5 1438.75 -2867.5 {
lab=GND}
N 1398.75 -2767.5 1438.75 -2767.5 {
lab=GND}
N 1398.75 -2667.5 1438.75 -2667.5 {
lab=GND}
N 1398.75 -2567.5 1438.75 -2567.5 {
lab=GND}
N 1398.75 -2467.5 1438.75 -2467.5 {
lab=GND}
N 1398.75 -2467.5 1398.75 -2417.5 {
lab=GND}
N 1398.75 -2667.5 1398.75 -2567.5 {
lab=GND}
N 1398.75 -2767.5 1398.75 -2667.5 {
lab=GND}
N 1458.75 -2517.5 1678.75 -2517.5 {
lab=#net3}
N 1458.75 -4137.5 1458.75 -4097.5 {
lab=VFS}
N 1398.75 -4067.5 1438.75 -4067.5 {
lab=GND}
N 1398.75 -4067.5 1398.75 -3967.5 {
lab=GND}
N 1458.75 -2617.5 1695 -2617.5 {
lab=#net2}
N 1458.75 -2717.5 1706.25 -2717.5 {
lab=#net4}
N 1458.75 -2817.5 1717.5 -2817.5 {
lab=#net5}
N 1458.75 -2917.5 1726.25 -2917.5 {
lab=#net6}
N 1458.75 -3017.5 1736.25 -3017.5 {
lab=#net7}
N 1458.75 -3117.5 1721.25 -3117.5 {
lab=#net8}
N 1458.75 -3217.5 1678.75 -3217.5 {
lab=#net9}
N 1458.75 -3317.5 1797.5 -3317.5 {
lab=#net10}
N 1458.75 -3417.5 1678.75 -3417.5 {
lab=#net11}
N 1458.75 -3517.5 1678.75 -3517.5 {
lab=#net12}
N 1458.75 -3617.5 1682.5 -3617.5 {
lab=#net13}
N 1458.75 -3717.5 1703.75 -3717.5 {
lab=#net14}
N 1458.75 -3817.5 1700 -3817.5 {
lab=#net15}
N 1458.75 -3917.5 1686.25 -3917.5 {
lab=#net16}
N 1458.75 -4017.5 1678.75 -4017.5 {
lab=#net17}
N 1398.75 -3867.5 1398.75 -3767.5 {
lab=GND}
N 1398.75 -3767.5 1398.75 -3667.5 {
lab=GND}
N 1398.75 -3667.5 1398.75 -3567.5 {
lab=GND}
N 1398.75 -3567.5 1398.75 -3467.5 {
lab=GND}
N 1398.75 -3467.5 1398.75 -3367.5 {
lab=GND}
N 1398.75 -3367.5 1398.75 -3267.5 {
lab=GND}
N 1398.75 -3267.5 1398.75 -3167.5 {
lab=GND}
N 1398.75 -3167.5 1398.75 -3067.5 {
lab=GND}
N 1398.75 -3067.5 1398.75 -2967.5 {
lab=GND}
N 1398.75 -2967.5 1398.75 -2867.5 {
lab=GND}
N 1398.75 -2867.5 1398.75 -2767.5 {
lab=GND}
N 1398.75 -2567.5 1398.75 -2467.5 {
lab=GND}
N 1458.75 -2437.5 1458.75 -2417.5 {
lab=VL}
N 1458.75 -2537.5 1458.75 -2517.5 {
lab=#net3}
N 1458.75 -2637.5 1458.75 -2617.5 {
lab=#net2}
N 1458.75 -2737.5 1458.75 -2717.5 {
lab=#net4}
N 1458.75 -2837.5 1458.75 -2817.5 {
lab=#net5}
N 1458.75 -2937.5 1458.75 -2917.5 {
lab=#net6}
N 1458.75 -3037.5 1458.75 -3017.5 {
lab=#net7}
N 1458.75 -3137.5 1458.75 -3117.5 {
lab=#net8}
N 1458.75 -3237.5 1458.75 -3217.5 {
lab=#net9}
N 1458.75 -3337.5 1458.75 -3317.5 {
lab=#net10}
N 1458.75 -3437.5 1458.75 -3417.5 {
lab=#net11}
N 1458.75 -3537.5 1458.75 -3517.5 {
lab=#net12}
N 1458.75 -3637.5 1458.75 -3617.5 {
lab=#net13}
N 1458.75 -3737.5 1458.75 -3717.5 {
lab=#net14}
N 1458.75 -3837.5 1458.75 -3817.5 {
lab=#net15}
N 1458.75 -3937.5 1458.75 -3917.5 {
lab=#net16}
N 1458.75 -4037.5 1458.75 -4017.5 {
lab=#net17}
N 1678.75 -4221.25 1812.5 -4221.25 {
lab=#net17}
N 1678.75 -4221.25 1678.75 -4017.5 {
lab=#net17}
N 1686.25 -4091.25 1686.25 -3917.5 {
lab=#net16}
N 1686.25 -4091.25 1812.5 -4091.25 {
lab=#net16}
N 1700 -3961.25 1700 -3817.5 {
lab=#net15}
N 1700 -3961.25 1813.75 -3961.25 {
lab=#net15}
N 1703.75 -3831.25 1703.75 -3717.5 {
lab=#net14}
N 1703.75 -3831.25 1812.5 -3831.25 {
lab=#net14}
N 1682.5 -3701.25 1812.5 -3701.25 {
lab=#net13}
N 1682.5 -3701.25 1682.5 -3617.5 {
lab=#net13}
N 1678.75 -3571.25 1812.5 -3571.25 {
lab=#net12}
N 1678.75 -3571.25 1678.75 -3517.5 {
lab=#net12}
N 1678.75 -3441.25 1812.5 -3441.25 {
lab=#net11}
N 1678.75 -3441.25 1678.75 -3417.5 {
lab=#net11}
N 1797.5 -3317.5 1797.5 -3311.25 {
lab=#net10}
N 1797.5 -3311.25 1812.5 -3311.25 {
lab=#net10}
N 1678.75 -3217.5 1678.75 -3181.25 {
lab=#net9}
N 1678.75 -3181.25 1812.5 -3181.25 {
lab=#net9}
N 1721.25 -3117.5 1721.25 -3051.25 {
lab=#net8}
N 1721.25 -3051.25 1812.5 -3051.25 {
lab=#net8}
N 1736.25 -3017.5 1736.25 -2921.25 {
lab=#net7}
N 1736.25 -2921.25 1812.5 -2921.25 {
lab=#net7}
N 1726.25 -2917.5 1726.25 -2791.25 {
lab=#net6}
N 1726.25 -2791.25 1812.5 -2791.25 {
lab=#net6}
N 1717.5 -2817.5 1717.5 -2661.25 {
lab=#net5}
N 1717.5 -2661.25 1812.5 -2661.25 {
lab=#net5}
N 1706.25 -2717.5 1706.25 -2531.25 {
lab=#net4}
N 1706.25 -2531.25 1812.5 -2531.25 {
lab=#net4}
N 1695 -2617.5 1695 -2401.25 {
lab=#net2}
N 1695 -2401.25 1812.5 -2401.25 {
lab=#net2}
N 1678.75 -2517.5 1678.75 -2271.25 {
lab=#net3}
N 1678.75 -2271.25 1813.75 -2271.25 {
lab=#net3}
N 2110 -4261.25 2365 -4261.25 {
lab=#net18}
N 2365 -4261.25 2365 -3383.75 {
lab=#net18}
N 2365 -3383.75 2515 -3383.75 {
lab=#net18}
N 2112.5 -4131.25 2352.5 -4131.25 {
lab=#net19}
N 2352.5 -4131.25 2352.5 -3363.75 {
lab=#net19}
N 2352.5 -3363.75 2515 -3363.75 {
lab=#net19}
N 2112.5 -4001.25 2340 -4001.25 {
lab=#net20}
N 2340 -4001.25 2340 -3343.75 {
lab=#net20}
N 2340 -3343.75 2515 -3343.75 {
lab=#net20}
N 2112.5 -3871.25 2322.5 -3871.25 {
lab=#net21}
N 2322.5 -3871.25 2322.5 -3323.75 {
lab=#net21}
N 2322.5 -3323.75 2515 -3323.75 {
lab=#net21}
N 2112.5 -3741.25 2312.5 -3741.25 {
lab=#net22}
N 2312.5 -3741.25 2312.5 -3303.75 {
lab=#net22}
N 2312.5 -3303.75 2515 -3303.75 {
lab=#net22}
N 2112.5 -3611.25 2297.5 -3611.25 {
lab=#net23}
N 2297.5 -3611.25 2297.5 -3283.75 {
lab=#net23}
N 2297.5 -3283.75 2515 -3283.75 {
lab=#net23}
N 2112.5 -3481.25 2290 -3481.25 {
lab=#net24}
N 2290 -3481.25 2290 -3263.75 {
lab=#net24}
N 2290 -3263.75 2515 -3263.75 {
lab=#net24}
N 2112.5 -3351.25 2275 -3351.25 {
lab=#net25}
N 2275 -3351.25 2275 -3243.75 {
lab=#net25}
N 2275 -3243.75 2515 -3243.75 {
lab=#net25}
N 2112.5 -3221.25 2497.5 -3221.25 {
lab=#net26}
N 2497.5 -3223.75 2497.5 -3221.25 {
lab=#net26}
N 2497.5 -3223.75 2515 -3223.75 {
lab=#net26}
N 2112.5 -3091.25 2142.5 -3091.25 {
lab=#net27}
N 2142.5 -3203.75 2142.5 -3091.25 {
lab=#net27}
N 2142.5 -3203.75 2515 -3203.75 {
lab=#net27}
N 2112.5 -2961.25 2160 -2961.25 {
lab=#net28}
N 2160 -3183.75 2160 -2961.25 {
lab=#net28}
N 2160 -3183.75 2515 -3183.75 {
lab=#net28}
N 2112.5 -2831.25 2195 -2831.25 {
lab=#net29}
N 2195 -3163.75 2195 -2831.25 {
lab=#net29}
N 2195 -3163.75 2515 -3163.75 {
lab=#net29}
N 2112.5 -2701.25 2227.5 -2701.25 {
lab=#net30}
N 2227.5 -3143.75 2227.5 -2701.25 {
lab=#net30}
N 2227.5 -3143.75 2515 -3143.75 {
lab=#net30}
N 2112.5 -2571.25 2272.5 -2571.25 {
lab=#net31}
N 2272.5 -3123.75 2272.5 -2571.25 {
lab=#net31}
N 2272.5 -3123.75 2515 -3123.75 {
lab=#net31}
N 2112.5 -2441.25 2297.5 -2441.25 {
lab=#net32}
N 2297.5 -3103.75 2297.5 -2441.25 {
lab=#net32}
N 2297.5 -3103.75 2515 -3103.75 {
lab=#net32}
N 2112.5 -2311.25 2337.5 -2311.25 {
lab=#net33}
N 2337.5 -3083.75 2337.5 -2311.25 {
lab=#net33}
N 2337.5 -3083.75 2515 -3083.75 {
lab=#net33}
C {devices/vsource.sym} 1320 -1813.75 0 0 {name=V4 value="pulse(0 1.8 8ns 1ns 1ns 20ns 40ns)" savecurrent=false}
C {devices/gnd.sym} 1320 -1743.75 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 1320 -1883.75 2 0 {name=p197 sig_type=std_logic lab=CLK}
C {devices/vsource.sym} 1160 -1553.75 0 0 {name=V1 value=1.8 savecurrent=false}
C {devices/gnd.sym} 1160 -1483.75 0 0 {name=l36 lab=GND}
C {devices/lab_pin.sym} 1190 -1583.75 2 0 {name=p198 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 1320 -1553.75 0 0 {name=V2 value=1.6 savecurrent=false}
C {devices/gnd.sym} 1320 -1483.75 0 0 {name=l37 lab=GND}
C {devices/lab_pin.sym} 1320 -1623.75 2 0 {name=p199 sig_type=std_logic lab=VFS}
C {devices/code_shown.sym} 1770 -1683.75 0 0 {name=COMMANDS only_toplevel=false value=
"
.options savecurrents
.control

save all

tran 0.005n 240n
write flashADC_Testing_v0p4p4.raw

.endc
"}
C {devices/vsource.sym} 1492.5 -1542.5 0 0 {name=V5 value=0.6 savecurrent=false}
C {devices/gnd.sym} 1492.5 -1492.5 0 0 {name=l2 lab=GND}
C {devices/vsource.sym} 940 -1813.75 0 0 {name=V7 value="PWL(0ns 0.5 230ns 1.7)" savecurrent=false}
C {devices/gnd.sym} 940 -1743.75 0 0 {name=l19 lab=GND}
C {devices/lab_pin.sym} 940 -1983.75 2 0 {name=p133 sig_type=std_logic lab=VIN}
C {devices/res.sym} 940 -1913.75 0 0 {name=R36
value=1k
footprint=1206
device=resistor
m=1}
C {devices/code.sym} 1820 -1903.75 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/vdd.sym} 1160 -1583.75 0 0 {name=l80 lab=VDD}
C {devices/lab_pin.sym} 1030 -1505 1 0 {name=p164 sig_type=std_logic lab=GND}
C {devices/gnd.sym} 1030 -1475 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 1492.5 -1600 2 0 {name=p2 sig_type=std_logic lab=VL}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -2467.5 0 0 {name=R1
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -2567.5 0 0 {name=R2
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -2667.5 0 0 {name=R3
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -2767.5 0 0 {name=R4
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -2867.5 0 0 {name=R5
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -2967.5 0 0 {name=R6
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3067.5 0 0 {name=R7
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3167.5 0 0 {name=R8
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3267.5 0 0 {name=R9
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3367.5 0 0 {name=R10
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3467.5 0 0 {name=R11
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3567.5 0 0 {name=R12
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3667.5 0 0 {name=R13
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3767.5 0 0 {name=R14
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3867.5 0 0 {name=R15
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -3967.5 0 0 {name=R16
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {sky130_fd_pr/res_xhigh_po_5p73.sym} 1458.75 -4067.5 0 0 {name=R18
L=2.865
model=res_xhigh_po_5p73
spiceprefix=X
mult=8}
C {/foss/designs/Analog_FA23_SP24/PriorityEncoder/xschem/16to4_PriorityEncoder_v0p0p1.sym} 2665 -3263.75 0 0 {name=x1}
C {devices/gnd.sym} 2515 -3423.75 1 0 {name=l40 lab=GND}
C {devices/opin.sym} 2815 -3443.75 0 0 {name=p173 lab=OUT3}
C {devices/opin.sym} 2815 -3423.75 0 0 {name=p158 lab=OUT2}
C {devices/opin.sym} 2815 -3403.75 0 0 {name=p159 lab=OUT1}
C {devices/opin.sym} 2815 -3383.75 0 0 {name=p160 lab=OUT0}
C {devices/ipin.sym} 1458.75 -4136.25 1 0 {name=p1 lab=VFS}
C {/foss/designs/Analog_FA23_SP24/PTAT/xschem/PTAT_v0p0p0.sym} 1498.75 -4258.75 0 0 {name=x18}
C {devices/gnd.sym} 1348.75 -4248.75 1 0 {name=l138 lab=GND}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -4081.25 0 0 {name=x2}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -3951.25 0 0 {name=x3}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -3821.25 0 0 {name=x4}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -3691.25 0 0 {name=x5}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -3561.25 0 0 {name=x6}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -3431.25 0 0 {name=x7}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -3301.25 0 0 {name=x8}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -3171.25 0 0 {name=x9}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -3041.25 0 0 {name=x10}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -2911.25 0 0 {name=x11}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -2781.25 0 0 {name=x12}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -2651.25 0 0 {name=x13}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -2521.25 0 0 {name=x14}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -2391.25 0 0 {name=x15}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -2261.25 0 0 {name=x16}
C {devices/gnd.sym} 1812.5 -4241.25 1 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} 1458.75 -2397.5 2 0 {name=p3 sig_type=std_logic lab=VL}
C {/foss/designs/Analog_FA23_SP24/flashADC/xschem/frontAnalog_v0p0p1.sym} 1962.5 -4211.25 0 0 {name=x17}
C {devices/lab_pin.sym} 1348.75 -4268.75 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1648.75 -4268.75 2 0 {name=p5 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -4161.25 0 0 {name=p6 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -4181.25 0 0 {name=p7 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -4201.25 0 0 {name=p8 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -4261.25 0 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -4111.25 1 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 1812.5 -4031.25 0 0 {name=p10 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -4051.25 0 0 {name=p11 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -4071.25 0 0 {name=p12 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -4131.25 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -3981.25 1 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 1812.5 -3901.25 0 0 {name=p14 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -3921.25 0 0 {name=p15 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -3941.25 0 0 {name=p16 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -4001.25 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -3851.25 1 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 1812.5 -3771.25 0 0 {name=p18 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -3791.25 0 0 {name=p19 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -3811.25 0 0 {name=p20 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -3871.25 0 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -3721.25 1 0 {name=l6 lab=GND}
C {devices/lab_pin.sym} 1812.5 -3641.25 0 0 {name=p22 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -3661.25 0 0 {name=p23 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -3681.25 0 0 {name=p24 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -3741.25 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -3591.25 1 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 1812.5 -3511.25 0 0 {name=p26 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -3531.25 0 0 {name=p27 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -3551.25 0 0 {name=p28 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -3611.25 0 0 {name=p29 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -3461.25 1 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 1812.5 -3381.25 0 0 {name=p30 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -3401.25 0 0 {name=p31 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -3421.25 0 0 {name=p32 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -3481.25 0 0 {name=p33 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -3331.25 1 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 1812.5 -3251.25 0 0 {name=p34 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -3271.25 0 0 {name=p35 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -3291.25 0 0 {name=p36 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -3351.25 0 0 {name=p37 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -3201.25 1 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 1812.5 -3121.25 0 0 {name=p38 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -3141.25 0 0 {name=p39 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -3161.25 0 0 {name=p40 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -3221.25 0 0 {name=p41 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -3071.25 1 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 1812.5 -2991.25 0 0 {name=p42 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -3011.25 0 0 {name=p43 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -3031.25 0 0 {name=p44 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -3091.25 0 0 {name=p45 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -2941.25 1 0 {name=l12 lab=GND}
C {devices/lab_pin.sym} 1812.5 -2861.25 0 0 {name=p46 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -2881.25 0 0 {name=p47 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -2901.25 0 0 {name=p48 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -2961.25 0 0 {name=p49 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -2811.25 1 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 1812.5 -2731.25 0 0 {name=p50 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -2751.25 0 0 {name=p51 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -2771.25 0 0 {name=p52 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -2831.25 0 0 {name=p53 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -2681.25 1 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 1812.5 -2601.25 0 0 {name=p54 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -2621.25 0 0 {name=p55 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -2641.25 0 0 {name=p56 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -2701.25 0 0 {name=p57 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -2551.25 1 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} 1812.5 -2471.25 0 0 {name=p58 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -2491.25 0 0 {name=p59 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -2511.25 0 0 {name=p60 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -2571.25 0 0 {name=p61 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -2421.25 1 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 1812.5 -2341.25 0 0 {name=p62 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -2361.25 0 0 {name=p63 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -2381.25 0 0 {name=p64 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -2441.25 0 0 {name=p65 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1812.5 -2291.25 1 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} 1812.5 -2211.25 0 0 {name=p66 sig_type=std_logic lab=IB}
C {devices/lab_pin.sym} 1812.5 -2231.25 0 0 {name=p67 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1812.5 -2251.25 0 0 {name=p68 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 1812.5 -2311.25 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2515 -3443.75 0 0 {name=p70 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2515 -3403.75 0 0 {name=p71 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 1398.75 -2417.5 0 0 {name=l18 lab=GND}
